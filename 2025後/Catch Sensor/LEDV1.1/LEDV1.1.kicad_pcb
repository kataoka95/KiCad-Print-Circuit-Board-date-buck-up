# Repository kataoka95/KiCad-Print-Circuit-Board-date-buck-up

## KiCad design 2025後/LINE Side/LINE Side V1.1/LINE Side V1.1.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7: D; D_SOD-123
D8, D9, D10, D11, D12, D13, D14, D15: LED; LED_0603_1608Metric
H1: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x04_Pin; PinSocket_1x04_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7: 22k; R_0603_1608Metric
R8, R9, R10, R11, R12, R13, R14: 4.7k; R_0603_1608Metric
R15, R16, R17, R18: 100; R_0603_1608Metric
T1, T2, T3, T4, T5, T6, T7: B19H1LS; LED_0603_1608Metric
U1, U2, U3, U4: LM393; D0008A-IPC_A

Connections:
+5V: D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), J1.2, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, T1.2 (A), T2.2 (A), T3.2 (A), T4.2 (A), T5.2 (A), T6.2 (A), T7.2 (A), U1.8 (V+), U2.8 (V+), U3.8 (V+), U4.8 (V+)
GND: J1.3, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R15.2, R16.2, R17.2, R18.2, U1.4 (V-), U2.4 (V-), U3.4 (V-), U4.4 (V-)
LINE 0: R1.1, T1.1 (K), U1.5 (+)
LINE 1: R2.1, T2.1 (K), U1.3 (+)
LINE 2: R3.1, T3.1 (K), U2.5 (+)
LINE 3: R4.1, T4.1 (K), U2.3 (+)
LINE 4: R5.1, T5.1 (K), U3.5 (+)
LINE 5: R6.1, T6.1 (K), U3.3 (+)
LINE 6: R7.1, T7.1 (K), U4.3 (+)
LINE Side 1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), J1.1
unnamed: D1.2 (A), R8.2, U1.1
unnamed: D2.2 (A), R9.2, U1.7
unnamed: D3.2 (A), R10.2, U2.1
unnamed: D4.2 (A), R11.2, U2.7
unnamed: D5.2 (A), R14.2, U4.1
unnamed: D6.2 (A), R13.2, U3.7
unnamed: D7.2 (A), R12.2, U3.1
unnamed: D8.1 (K), D9.1 (K), R15.1
unnamed: D10.1 (K), D11.1 (K), R16.1
unnamed: D12.1 (K), D13.1 (K), R17.1
unnamed: D14.1 (K), D15.1 (K), R18.1
Threshold V: J1.4, U1.2 (-), U1.6 (-), U2.2 (-), U2.6 (-), U3.2 (-), U3.6 (-), U4.2 (-)

Notes on the sheet:
コンパレーター（LM393）
コネクタ
LED
フォトトランジスタ（B19H1LS）

Board: 2 copper layers, 23.4 x 84.3 mm, 46 parts (30 on the bottom side), 22 nets.

File 2025後/LINE Side/LINE Side V1.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"D1, D2, D3, D4, D5, D6, D7",D_SOD-123,7,D,
"D10, D11, D12, D13, D14, D15, D8, D9",0603,8,LED,
J1,PinSocket_1x04_P2.54mm_Vertical,1,Conn_01x04_Pin,
"R1, R2, R3, R4, R5, R6, R7",0603,7,22k,
"R10, R11, R12, R13, R14, R8, R9",0603,7,4.7k,
"R15, R16, R17, R18",0603,4,100,
"T1, T2, T3, T4, T5, T6, T7",0603,7,B19H1LS,
"U1, U2, U3, U4",D0008A-IPC_A,4,LM393,

## KiCad design 2025後/Line Bridge/Line Bridge/Line Bridge.kicad_pcb

Parts:
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1, J2: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical

Connections:
+5V: J1.2, J2.2
GND: J1.3, J2.3
OUT: J1.1, J2.1
ThrV: J1.4, J2.4

Notes on the sheet:
コネクタ

Board: 2 copper layers, 43.0 x 10.5 mm, 4 parts (2 on the bottom side), 4 nets.

File 2025後/Line Bridge/Line Bridge/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"J1, J2",PinHeader_1x04_P2.54mm_Vertical,2,Conn_01x04_Pin,

## KiCad design 2025後/Main/Main V1.1/MainV1.1.kicad_pcb

Parts:
A1: TEENSY4.1
BNO1: Conn_01x08_Pin; BNO055
BZ1: Buzzer; Buzzer UDX01CLFPH
C1, C6, C7, C8, C9: 0.1μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C5, C27, C28, C29, C30, C31, C32: 0.1uF; C_0402_1005Metric
C10: 100uF; CP_Radial_D6.3mm_P2.50mm
C11: 10uF; C_0603_1608Metric
C12: 0.1uF; C_0603_1608Metric
Camera1, Camera2: Conn_01x04_Pin; GROVE-HW4-2.0
CatchSensor1: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
D1: D_Schottky; D_SMA
F1: Fuse; MFR300
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J2: Conn_02x04_Odd_Even; PinSocket_2x04_P2.54mm_Vertical
J3: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
J6: Conn_01x08_Pin; FFC conector 0.5mm Pich
KICK1: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
LED1: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
LINE1: Conn_01x04_Pin; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R1: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6: 1kΩ; R_0603_1608Metric
U1: XIAO_RP2040_Back_Ver; XIAO-RP2040-DIP
U2, U3: ADM3202ARUZ-REEL7; RU_16_ADI
encoder1, encoder2, encoder3, encoder4: Conn_01x04_Pin; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal

Connections:
1C1+: C2.2, U2.1 (C1+)
1C1-: C2.1, U2.3 (C1-)
1C2+: C3.2, U2.4 (C2+)
1C2-: C3.1, U2.5 (C2-)
1V+: C27.2, U2.2 (V+)
1V-: C29.2, U2.6 (V-)
2C1+: C4.2, U3.1 (C1+)
2C1-: C4.1, U3.3 (C1-)
2C2+: C5.2, U3.4 (C2+)
2C2-: C5.1, U3.5 (C2-)
2V+: C30.2, U3.2 (V+)
2V-: C31.2, U3.6 (V-)
+3.3V: A1.3V3 (3.3V), A1.3V3@2 (3.3V), A1.3V3@3 (3.3V), BNO1.1, C1.1, C6.1, C7.1, C8.1, C9.1, C27.1, C28.1, C30.1, C32.1, CatchSensor1.1, R5.2, R6.2, U1.3 (3V3), U2.16 (VCC), U3.16 (VCC), encoder1.1, encoder2.1, encoder3.1, encoder4.1
+5V: A1.VIN, C10.1, C11.1, C12.1, Camera1.3, Camera2.3, D1.2 (A), F1.2, J2.2, LINE1.1, R1.2
Ball Catch Sensor: A1.D22 (A8), CatchSensor1.2, R2.1
Buzzer: A1.D23 (A9), BZ1.1 (+)
Cam1 RX: A1.D21 (A7), Camera1.2
Cam1 TX: A1.D20 (A6), Camera1.1
Cam2 RX: A1.D16 (A2), Camera2.2
Cam2 TX: A1.D17 (A3), Camera2.1
GND: A1.AGND/GND (GND), A1.GND, A1.GND@2 (GND), BNO1.2, BZ1.2 (-), C1.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C28.2, C29.1, C31.1, C32.2, Camera1.4, Camera2.4, J1.2, J2.1, KICK1.3, LED1.2, LINE1.2, R2.2, U1.2 (GND), U2.15 (GND), U3.15 (GND), encoder1.4, encoder2.4, encoder3.4, encoder4.4
Gyro-SCL: A1.D24 (A10), BNO1.4, R5.1
Gyro-SDA: A1.D25 (A11), BNO1.3, R6.1
KICK 1: A1.D32, KICK1.1
KICK 2: A1.D31, KICK1.2
LINE RX: A1.D34, U3.9 (R2OUT)
LINE RX_RS232C: LINE1.3, U3.8 (R2IN)
LINE TX: A1.D35, U3.10 (T2IN)
LINE TX_RS232C: LINE1.4, U3.7 (T2OUT)
M1 EN: A1.D4, J6.3
M1 PH: A1.D5, J6.4
M2 EN: A1.D2, J6.1
M2 PH: A1.D3, J6.2
M3 EN: A1.D8, J6.7
M3 PH: A1.D9, J6.8
M4 EN: A1.D6, J6.5
M4 PH: A1.D7, J6.6
unnamed: D1.1 (K), U1.1 (VCC)
unnamed: F1.1, J1.1
unnamed: LED1.1, R1.1
RP2040 RX: A1.D15 (A1), U1.8 (D6)
RP2040 TX: A1.D14 (A0), U1.7 (D7)
RX_Ball: A1.D0 ((CRX1)D0), U2.12 (R1OUT)
RX_Ball RS232C: J2.3, U2.13 (R1IN)
RX_ESP: A1.D28, U2.9 (R2OUT)
RX_ESP RS232C: J2.5, U2.8 (R2IN)
TX_Ball: A1.D1 ((CTX1)D1), U2.11 (T1IN)
TX_Ball RS232C: J2.4, U2.14 (T1OUT)
TX_ESP: A1.D29, U2.10 (T2IN)
TX_ESP RS232C: J2.6, U2.7 (T2OUT)
Teensy4.1_D+: J2.7, J3.1
Teensy4.1_D-: J2.8, J3.2
encoder1 A: U1.6 (D8), encoder1.2
encoder1 B: U1.5 (D9), encoder1.3
encoder2 A: U1.13 (D1), encoder2.2
encoder2 B: U1.14 (D0), encoder2.3
encoder3 A: U1.10 (D4), encoder3.2
encoder3 B: U1.9 (D5), encoder3.3
encoder4 A: U1.12 (D2), encoder4.2
encoder4 B: U1.11 (D3), encoder4.3

Notes on the sheet:
ラインセンサー基板通信用コネクタ
モタドラ基板通信用コネクタ
カメラ用コネクタ（TX,RX逆転処置はここで、）
エンコーダー処理用マイコン（XIAO RP2040）｛TX,RX逆転処置はここで、｝
キッカー基板通信用
Ball Catch(まだ抵抗値決めれてない)
エンコーダー用コネクタ（モーター付属エンコーダー）
ボールセンサー基板通信用コネクタ（TX,RX逆転処置はここで、）
電源供給コネクタ
ジャイロ（BNO055）
Teensy4.1
ブザー
RS-232Cレベル変換回路

Board: 2 copper layers, 100.0 x 100.0 mm, 48 parts (17 on the bottom side), 60 nets.

File 2025後/Main/Main V1.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
A1,TEENSY4.1,1,TEENSY4.1,
BNO1,BNO055,1,Conn_01x08_Pin,
BZ1,Buzzer UDX01CLFPH,1,Buzzer,
"C1, C6, C7, C8, C9",0603,5,0.1μF,
C10,CP_Radial_D6.3mm_P2.50mm,1,100uF,
C11,0603,1,10uF,
C12,0603,1,0.1uF,
"C2, C27, C28, C29, C3, C30, C31, C32, C4, C5",0402,10,0.1uF,
"CAMERA1, CAMERA2",GROVE-HW4-2.0,2,Conn_01x04_Pin,
"CATCHSENSOR1, J1, LED1",JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,3,Conn_01x02_Pin,
D1,D_SMA,1,D_Schottky,
"ENCODER1, ENCODER2, ENCODER3, ENCODER4",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,4,Conn_01x04_Pin,
F1,MFR300,1,Fuse,
J2,PinSocket_2x04_P2.54mm_Vertical,1,Conn_02x04_Odd_Even,
J3,PinSocket_1x02_P2.54mm_Vertical,1,Conn_01x02_Pin,
J6,FFC conector 0.5mm Pich,1,Conn_01x08_Pin,
KICK1,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,1,Conn_01x03_Pin,
LINE1,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,Conn_01x04_Pin,
"R1, R2",R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,2,R,
"R5, R6",0603,2,1kΩ,
U1,XIAO-RP2040-DIP,1,XIAO_RP2040_Back_Ver,
"U2, U3",RU_16_ADI,2,ADM3202ARUZ-REEL7,

## KiCad design 2025後/Motor Driver IC/Motor Driver DRV8874 V1/Motor Driver DRV8874 V1.kicad_pcb

Parts:
C1: 22nF; C_0603_1608Metric
C2, C3: 0.1uF; C_0603_1608Metric
J1, J2: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
R1, R3, R4: 10k; R_0402_1005Metric
R2: 2.49k; R_0402_1005Metric
U1: DRV8874PWPR; DRV8874

Connections:
+3.3V: J2.2, J2.3, R1.1, R3.1, R4.1, U1.7 (IMODE), U1.16 (PMODE)
GND: C3.2, J1.1, J2.5, R2.2, U1.9 (PGND), U1.15 (GND), U1.17 (PAD)
unnamed: C1.1, U1.13 (CPH)
unnamed: C1.2, U1.14 (CPL)
unnamed: R2.1, U1.6 (IPROPI)
unnamed: R3.2, U1.4 (NFAULT)
unnamed: R1.2, U1.3 (NSLEEP)
unnamed: C2.2, U1.12 (VCP)
unnamed: R4.2, U1.5 (VREF)
OUT1: J1.4, U1.8 (OUT1)
OUT2: J2.4, U1.10 (OUT2)
PWM IN1: J1.2, U1.1 (EN/IN1)
PWM IN 2: J1.3, U1.2 (PH/IN2)
VCC: C2.1, C3.1, J1.5, J2.1, U1.11 (VM)

Board: 2 copper layers, 14.0 x 25.0 mm, 10 parts (2 on the bottom side), 14 nets.

File 2025後/Motor Driver IC/Motor Driver DRV8874 V2.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,22nF,
"C2, C3",0603,2,0.1uF,
"J1, J2",PinHeader_1x05_P2.54mm_Vertical,2,Conn_01x05_Pin,
"R1, R3, R4",0402,3,10k,
R2,0402,1,2.49k,
U1,DRV8874 IC,1,DRV8874PWPR,

## KiCad design 2025後/Motor Driver/Motor Driver V1.1/Motor Driver V1.1.kicad_pcb

Parts:
C1, C2, C3, C4: 150uF; CP_Radial_D8.0mm_P3.50mm
D1: LED; LED_0603_1608Metric
J1: Conn_01x08_Pin; FFC conector 8Pin
J2: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
R1: 350; R_0603_1608Metric
U1, U2, U3, U4: DRV8874 Module
conn1, conn2, conn3, conn4: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal

Connections:
+3.3V: J2.2, U1.7 (+3.3V), U1.8 (+3.3V), U2.7 (+3.3V), U2.8 (+3.3V), U3.7 (+3.3V), U3.8 (+3.3V), U4.7 (+3.3V), U4.8 (+3.3V)
D1 EN: J1.7, U1.2 (PWM_1)
D1 OUT1: U1.4 (OUT_1), conn1.1
D1 OUT2: U1.9 (OUT_2), conn1.2
D1 PH: J1.8, U1.3 (PWM_2)
D2 EN: J1.3, U2.2 (PWM_1)
D2 OUT1: U2.4 (OUT_1), conn2.1
D2 OUT2: U2.9 (OUT_2), conn2.2
D2 PH: J1.4, U2.3 (PWM_2)
D3 EN: J1.1, U3.2 (PWM_1)
D3 OUT1: U3.4 (OUT_1), conn3.1
D3 OUT2: U3.9 (OUT_2), conn3.2
D3 PH: J1.2, U3.3 (PWM_2)
D4 EN: J1.5, U4.2 (PWM_1)
D4 OUT1: U4.4 (OUT_1), conn4.1
D4 OUT2: U4.9 (OUT_2), conn4.2
D4 PH: J1.6, U4.3 (PWM_2)
GND: C1.2, C2.2, C3.2, C4.2, J2.3, R1.2, U1.1 (GND), U1.10 (GND), U2.1 (GND), U2.10 (GND), U3.1 (GND), U3.10 (GND), U4.1 (GND), U4.10 (GND)
unnamed: D1.1 (K), R1.1
VCC: C1.1, C2.1, C3.1, C4.1, D1.2 (A), J2.1, U1.5 (VCC), U1.6 (VCC), U2.5 (VCC), U2.6 (VCC), U3.5 (VCC), U3.6 (VCC), U4.5 (VCC), U4.6 (VCC)

Board: 2 copper layers, 65.0 x 40.0 mm, 16 parts (0 on the bottom side), 20 nets.
