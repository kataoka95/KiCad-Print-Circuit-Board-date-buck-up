# Repository kataoka95/KiCad-Print-Circuit-Board-date-buck-up

## KiCad design 2025後/Motor Driver/Motor Driver V1.3/Motor Driver V1.3.kicad_pcb

Parts:
C1, C2, C3, C4: 150uF; CP_Radial_D8.0mm_P3.50mm
D1: LED; LED_0603_1608Metric
J1: Conn_01x08_Pin; FFC conector 8Pin
J2: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
R1: 350; R_0603_1608Metric
U1, U2, U3, U4: DRV8874 Module V1.2
conn1, conn2, conn3, conn4: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal

Connections:
+3.3V: J2.2, U1.4 (+3.3V), U1.7 (+3.3V), U2.4 (+3.3V), U2.7 (+3.3V), U3.4 (+3.3V), U3.7 (+3.3V), U4.4 (+3.3V), U4.7 (+3.3V)
D1 EN: J1.7, U1.1 (PWM_IN1)
D1 OUT1: U1.5 (OUT1), conn1.1
D1 OUT2: U1.10 (OUT2), conn1.2
D1 PH: J1.8, U1.2 (PWM_IN2)
D2 EN: J1.3, U2.1 (PWM_IN1)
D2 OUT1: U2.5 (OUT1), conn2.1
D2 OUT2: U2.10 (OUT2), conn2.2
D2 PH: J1.4, U2.2 (PWM_IN2)
D3 EN: J1.1, U3.1 (PWM_IN1)
D3 OUT1: U3.5 (OUT1), conn3.1
D3 OUT2: U3.10 (OUT2), conn3.2
D3 PH: J1.2, U3.2 (PWM_IN2)
D4 EN: J1.5, U4.1 (PWM_IN1)
D4 OUT1: U4.5 (OUT1), conn4.1
D4 OUT2: U4.10 (OUT2), conn4.2
D4 PH: J1.6, U4.2 (PWM_IN2)
GND: C1.2, C2.2, C3.2, C4.2, J2.3, R1.2, U1.6 (GND), U1.8 (GND), U2.6 (GND), U2.8 (GND), U3.6 (GND), U3.8 (GND), U4.6 (GND), U4.8 (GND)
unnamed: D1.1 (K), R1.1
VCC: C1.1, C2.1, C3.1, C4.1, D1.2 (A), J2.1, U1.3 (VCC), U1.9 (VCC), U2.3 (VCC), U2.9 (VCC), U3.3 (VCC), U3.9 (VCC), U4.3 (VCC), U4.9 (VCC)

Board: 2 copper layers, 70.0 x 48.3 mm, 16 parts (0 on the bottom side), 20 nets.

## KiCad design 2025後/Motor Driver/Motor Driver V2.1/Motor Driver V2.1.kicad_pcb

Parts:
C1, C2, C3, C4: 150uF; 293D157X9016D2TE3
C5, C6, C8, C9, C11, C12, C15: 0.1uF; C_0603_1608Metric
C7, C10, C16: 22nF; C_0603_1608Metric
C13: 22nF; C_0402_1005Metric
C14: 0.1uF; C_0402_1005Metric
D1: LED; LED_0603_1608Metric
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x08_Pin; FFC conector 0.5mm Pich
J2: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
Motor1, Motor2, Motor3, Motor4: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
R1, R3, R4, R5, R6, R7, R9, R10, R11, R13, R14, R15: 10k; R_0402_1005Metric
R2, R8, R12, R16: 2.49k; R_0402_1005Metric
R17: 150; R_0402_1005Metric
U1, U2, U3, U4: DRV8874PWPR; DRV8874 IC

Connections:
+3.3V: J2.2, R1.1, R3.1, R4.1, R5.1, R6.1, R7.1, R9.1, R10.1, R11.1, R13.1, R14.1, R15.1, U1.7 (IMODE), U1.16 (PMODE), U2.7 (IMODE), U2.16 (PMODE), U3.7 (IMODE), U3.16 (PMODE), U4.7 (IMODE), U4.16 (PMODE)
D1 OUT1: Motor1.1, U1.8 (OUT1)
D1 OUT2: Motor1.2, U1.10 (OUT2)
D1 PWM IN1: J1.6, U1.1 (EN/IN1)
D1 PWM IN2: J1.5, U1.2 (PH/IN2)
D2 OUT1: Motor4.1, U4.8 (OUT1)
D2 OUT2: Motor4.2, U4.10 (OUT2)
D2 PWM IN1: J1.8, U4.1 (EN/IN1)
D2 PWM IN2: J1.7, U4.2 (PH/IN2)
D3 OUT1: Motor3.1, U3.8 (OUT1)
D3 OUT2: Motor3.2, U3.10 (OUT2)
D3 PWM IN1: J1.2, U3.1 (EN/IN1)
D3 PWM IN2: J1.1, U3.2 (PH/IN2)
D4 OUT1: Motor2.1, U2.8 (OUT1)
D4 OUT2: Motor2.2, U2.10 (OUT2)
D4 PWM IN1: J1.4, U2.1 (EN/IN1)
D4 PWM IN2: J1.3, U2.2 (PH/IN2)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C9.2, C12.2, C15.2, D1.1 (K), J2.3, R2.2, R8.2, R12.2, R16.2, U1.9 (PGND), U1.15 (GND), U1.17 (PAD), U2.9 (PGND), U2.15 (GND), U2.17 (PAD), U3.9 (PGND), U3.15 (GND), U3.17 (PAD), U4.9 (PGND), U4.15 (GND), U4.17 (PAD)
unnamed: D1.2 (A), R17.2
unnamed: C13.1, U1.13 (CPH)
unnamed: C13.2, U1.14 (CPL)
unnamed: R2.1, U1.6 (IPROPI)
unnamed: R3.2, U1.4 (NFAULT)
unnamed: R1.2, U1.3 (NSLEEP)
unnamed: C14.2, U1.12 (VCP)
unnamed: R4.2, U1.5 (VREF)
unnamed: C10.1, U2.13 (CPH)
unnamed: C10.2, U2.14 (CPL)
unnamed: R16.1, U2.6 (IPROPI)
unnamed: R15.2, U2.4 (NFAULT)
unnamed: R13.2, U2.3 (NSLEEP)
unnamed: C11.2, U2.12 (VCP)
unnamed: R14.2, U2.5 (VREF)
unnamed: C7.1, U3.13 (CPH)
unnamed: C7.2, U3.14 (CPL)
unnamed: R12.1, U3.6 (IPROPI)
unnamed: R11.2, U3.4 (NFAULT)
unnamed: R9.2, U3.3 (NSLEEP)
unnamed: C8.2, U3.12 (VCP)
unnamed: R10.2, U3.5 (VREF)
unnamed: C16.1, U4.13 (CPH)
unnamed: C16.2, U4.14 (CPL)
unnamed: R8.1, U4.6 (IPROPI)
unnamed: R7.2, U4.4 (NFAULT)
unnamed: R5.2, U4.3 (NSLEEP)
unnamed: C5.2, U4.12 (VCP)
unnamed: R6.2, U4.5 (VREF)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, C9.1, C11.1, C12.1, C14.1, C15.1, J2.1, R17.1, U1.11 (VM), U2.11 (VM), U3.11 (VM), U4.11 (VM)

Notes on the sheet:
これはD4のこと
[悲報]Motor2とMotor4の配置をミスったためおかしなことになっていますが気にしないでください
これはD2のこと
コネクタ類
モーター出力コネクタ
モーター用コンデンサー
通電確認用LED
モタドラIC

Board: 2 copper layers, 70.4 x 31.7 mm, 46 parts (19 on the bottom side), 48 nets.

File 2025後/Motor Driver/Motor Driver V2.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4",293D157X9016D2TE3,4,150uF,
"C10, C16, C7",0603,3,22nF,
"C11, C12, C15, C5, C6, C8, C9",0603,7,0.1uF,
C13,0402,1,22nF,
C14,0402,1,0.1uF,
D1,0603,1,LED,
J1,FFC conector 0.5mm Pich,1,Conn_01x08_Pin,
J2,JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,1,Conn_01x03_Pin,
"MOTOR1, MOTOR2, MOTOR3, MOTOR4",JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,4,Conn_01x02_Pin,
"R1, R10, R11, R13, R14, R15, R3, R4, R5, R6, R7, R9",0402,12,10k,
"R12, R16, R2, R8",0402,4,2.49k,
R17,0402,1,150,
"U1, U2, U3, U4",DRV8874 IC,4,DRV8874PWPR,

## KiCad design 2025後/Power/Power V1.1/Power V1.1.kicad_pcb

Board: 2 copper layers, 72.8 x 38.9 mm, 30 parts (8 on the bottom side), 12 nets.

Parts:
C1: 1000uF; CAP_J-V_10X10P5_RUB
C2: 22uF; C_0805_2012Metric
C3: 10uF; C_0603_1608Metric
C4, C6: 0.1uF; C_0603_1608Metric
C5: 47uF; C_0805_2012Metric
C7: 100uF; CP_Radial_D5.0mm_P2.50mm
D1: GS1010FL; Nexperia_CFP3_SOD-123W
D2, D4: LED; LED_0603_1608Metric
D3: D; Nexperia_CFP3_SOD-123W
F1: Fuse; Fuseholder_Clip-5x20mm_Eaton_1A5601-01_Inline_P20.80x6.76mm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
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Pin; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J2: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
KICK1: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
L1: CSAB1260A; L_Changjiang_FXL1360
MAIN1: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
MD1: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
Q1: PMOS; TO-252-2
R1: 20k; R_0603_1608Metric
R2: 1.2k; R_0603_1608Metric
R3: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R4: 1k; R_0603_1608Metric
RV1: 20k; TC33X-2-203E
SW1: SW_SPST; DS-850K-S-ON
U1: OKL-T/6-W12N-C; OKL-T6-W12N-C
U2: AZ1117CH-3.3TRG1; SOT-223
U3: LM2576SX-5.0_NOPB

Connections:
+3.3V: C5.1, C6.1, D1.2 (A), MD1.2, U2.2 (OUTPUT)
+5V: C3.1, C7.1, L1.2, MAIN1.1, R4.1, U1.4 (VOUT1), U1.5 (SENSE), U3.4 (FB)
+12V: C1.1, C2.1, C4.1, D1.1 (K), J2.1, KICK1.1, MD1.1, Q1.2 (D), R1.1, U1.2 (VIN), U2.3 (INPUT), U3.1 (VIN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D2.1 (K), D3.2 (A), D4.1 (K), J1.2, J2.2, KICK1.2, MAIN1.2, MD1.3, R1.2, R2.2, U1.1 (ON/OFF), U1.3 (GND), U1.7 (GND), U2.1 (ADJ/GND), U2.4 (EPAD), U3.3 (GND), U3.6 (GND__1)
unnamed: D2.2 (A), R4.2
unnamed: D3.1 (K), L1.1, U3.2 (OUT)
unnamed: J1.1, SW1.1 (A)
unnamed: Q1.1 (G), R3.2
unnamed: F1.2, Q1.3 (S), R3.1
unnamed: R2.1, RV1.2, RV1.3
unnamed: F1.1, SW1.2 (B)
Trim: RV1.1, U1.6 (TRIM1)

## KiCad design 自作キーボード/tsuru-main/kicad_ch552t/kicad_ch552t.kicad_pcb

Board: 2 copper layers, 207.8 x 57.2 mm, 66 parts (28 on the bottom side), 57 nets.

Parts:
C1, C2: 100nF; C_0402_1005Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15: BAV70_Small; apfel_SOT-23_silkless
D16: PMEG2010EA; D_0402_1005Metric
F1: 500mA; Fuse_0402_1005Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_Pad_Via_nosilk
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX30, MX31, MX32: MX_SW_HS; MX-HotswapSAFE_no_silk
R1, R2: 5.1k; R_0402_1005Metric
R3: 10k; R_0402_1005Metric
S1: MX_stab; STAB_MX_P_3u
S2: MX_stab; STAB_MX_ISO-ROT
SW1: BOOT; SW_Push_SPST_NO_Alps_SKRK
SW2: RESET; SW_Push_SPST_NO_Alps_SKRK
U1: TSSOP-20_4.4x6.5mm_P0.65mm
U2: USBLC6-2SC6; SOT-23-6
tsuru: LOGO

Connections:
+3.3V: C2.1, SW1.2, SW2.2, U1.20 (V33)
BOOT: R3.2, SW1.1
CC1: J1.A5 (CC1), R1.1
CC2: J1.B5 (CC2), R2.1
GND: C1.2, C2.2, H1.1, H2.1, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R1.2, R2.2, U1.18 (GND), U2.2 (GND)
unnamed: D1.1 (A1), MX1.1
unnamed: D1.2 (A2), MX2.2
unnamed: D2.1 (A1), MX3.1
unnamed: D2.2 (A2), MX4.2
unnamed: D3.1 (A1), MX5.1
unnamed: D3.2 (A2), MX6.2
unnamed: D4.1 (A1), MX7.1
unnamed: D4.2 (A2), MX8.2
unnamed: D5.1 (A1), MX9.1
unnamed: D5.2 (A2), MX10.2, MX32.1
unnamed: D6.1 (A1), MX11.2
unnamed: D6.2 (A2), MX12.1
unnamed: D7.1 (A1), MX13.2
unnamed: D7.2 (A2), MX14.1
unnamed: D8.1 (A1), MX15.2
unnamed: D8.2 (A2), MX16.1
unnamed: D9.1 (A1), MX17.2
unnamed: D9.2 (A2), MX18.1
unnamed: D10.1 (A1), MX19.2
unnamed: D10.2 (A2), MX20.1
unnamed: D11.1 (A1), MX21.1
unnamed: D11.2 (A2), MX22.2
unnamed: D12.1 (A1), MX23.1
unnamed: D12.2 (A2), MX24.2
unnamed: D13.1 (A1), MX25.2
unnamed: D13.2 (A2), MX26.1
unnamed: D14.1 (A1), MX27.1
unnamed: D14.2 (A2), MX28.2
unnamed: D15.1 (A1), MX29.1
unnamed: D15.2 (A2), MX30.2
unnamed: D16.2 (A), F1.1
PORT+: J1.A6 (D+), J1.B6 (D+), U2.6 (I/O1)
PORT-: J1.A7 (D-), J1.B7 (D-), U2.4 (I/O2)
RST: SW2.1, U1.6 (RST)
UDM: U1.15 (P3.7), U2.3 (I/O2)
UDP: R3.1, U1.14 (P3.6), U2.1 (I/O1)
VBUS: F1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
VCC: C1.1, D16.1 (K), U1.19 (VCC), U2.5 (VBUS)
c0: MX1.2, MX11.1, MX21.2, U1.16 (P1.3)
c1: MX2.1, MX12.2, MX22.1, U1.17 (P1.2)
c2: MX3.2, MX13.1, MX23.2, U1.11 (P3.3)
c3: MX4.1, MX14.2, MX24.1, U1.9 (P3.1)
c4: MX5.2, MX15.1, MX25.1, MX31.2, U1.1 (P3.2)
c5: MX6.1, MX16.2, MX26.2, U1.3 (P1.5)
c6: MX7.2, MX17.1, MX27.2, U1.4 (P1.6)
c7: MX8.1, MX18.2, MX28.1, U1.5 (P1.7)
c8: MX9.2, MX19.1, MX29.2, U1.7 (P1.0)
c9: MX10.1, MX20.2, MX30.1, MX32.2, U1.8 (P1.1)
r0: D1.3 (K), D2.3 (K), D3.3 (K), D4.3 (K), D5.3 (K), U1.13 (P3.5)
r1: D6.3 (K), D7.3 (K), D8.3 (K), D9.3 (K), D10.3 (K), U1.12 (P3.4)
r2: D11.3 (K), D12.3 (K), D13.3 (K), D14.3 (K), D15.3 (K), U1.10 (P3.0)
r3: MX31.1, U1.2 (P1.4)

File 自作キーボード/tsuru-main/kicad_ch552t/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0402,2,100nF,C1525
"D1, D10, D11, D12, D13, D14, D15, D2, D3, D4, D5, D6, D7, D8, D9",apfel_SOT-23_silkless,15,BAV70_Small,
D16,0402,1,PMEG2010EA,C2837790
F1,0402,1,500mA,C18198354
"H1, H2, H3, H4",MountingHole_2.2mm_M2_Pad_Via_nosilk,4,MountingHole_Pad,
J1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB_C_Receptacle_USB2.0,C2765186
"MX1, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX2, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX3, MX30, MX31, MX32, MX4, MX5, MX6, MX7, MX8, MX9",MX-HotswapSAFE_no_silk,32,MX_SW_HS,C5184526
"R1, R2",0402,2,5.1k,C25905
R3,0402,1,10k,C25744
S1,STAB_MX_P_3u,1,MX_stab,
S2,STAB_MX_ISO-ROT,1,MX_stab,
SW1,SW_Push_SPST_NO_Alps_SKRK,1,BOOT,C115357
SW2,SW_Push_SPST_NO_Alps_SKRK,1,RESET,C115357
U1,TSSOP-20_4.4x6.5mm_P0.65mm,1,~,C111367
U2,SOT-23-6,1,USBLC6-2SC6,C2687116
