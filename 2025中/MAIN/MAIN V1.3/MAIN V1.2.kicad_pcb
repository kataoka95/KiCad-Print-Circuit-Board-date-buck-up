# Repository kataoka95/KiCad-Print-Circuit-Board-date-buck-up (continued)

## KiCad design 2025中/MOTOR Driver/Motor Driver V1.2/Motor Driver V1.1.kicad_pcb

Parts:
C1, C2, C3, C4: 150uF; 293D157X9016D2TE3
C5, C6, C7, C8: 0.1uF; R_0603_1608Metric
D1: LED; LED_0603_1608Metric
H1, H2: MountingHole; MountingHole_3.2mm_M3
IC1, IC2, IC3, IC4: BD63150AFM-E2; Manufacturer_Part_Number BD63150AFM-E2; Mouser Part Number 755-BD63150AFM-E2
J1: Conn_01x08_Pin; FFC conector 0.5mm Pich
J2: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
Motor1, Motor2, Motor3, Motor4: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
R1, R3, R5, R7: 1.2k; R_0603_1608Metric
R2, R4, R6, R8: 1k; R_0603_1608Metric
R17: 150; R_0603_1608Metric

Connections:
+3.3V: IC1.13 (PS), IC2.13 (PS), IC3.13 (PS), IC4.13 (PS), J2.2, R1.1, R3.1, R5.1, R7.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, IC1.15 (TEST), IC1.16 (FAILA), IC1.18 (TEST1), IC1.22 (GND_1), IC1.29 (GND_2), IC1.32 (RNFS), IC1.33 (RNF_1), IC1.34 (RNF_2), IC1.35 (RNF_3), IC1.37 (FIN_1), IC1.38 (FIN_2), IC2.15 (TEST), IC2.16 (FAILA), IC2.18 (TEST1), IC2.22 (GND_1), IC2.29 (GND_2), IC2.32 (RNFS), IC2.33 (RNF_1), IC2.34 (RNF_2), IC2.35 (RNF_3), IC2.37 (FIN_1), IC2.38 (FIN_2), IC3.15 (TEST), IC3.16 (FAILA), IC3.18 (TEST1), IC3.22 (GND_1), IC3.29 (GND_2), IC3.32 (RNFS), IC3.33 (RNF_1), IC3.34 (RNF_2), IC3.35 (RNF_3), IC3.37 (FIN_1), IC3.38 (FIN_2), IC4.15 (TEST), IC4.16 (FAILA), IC4.18 (TEST1), IC4.22 (GND_1), IC4.29 (GND_2), IC4.32 (RNFS), IC4.33 (RNF_1), IC4.34 (RNF_2), IC4.35 (RNF_3), IC4.37 (FIN_1), IC4.38 (FIN_2), J2.3, R2.2, R4.2, R6.2, R8.2, R17.2
M1 IN1: IC1.11 (IN1), J1.7
M1 IN2: IC1.12 (IN2), J1.8
M1 OUT1: IC1.1 (OUT1_1), IC1.2 (OUT1_2), IC1.3 (OUT1_3), Motor1.1
M1 OUT2: IC1.6 (OUT2_1), IC1.7 (OUT2_2), IC1.8 (OUT2_3), Motor1.2
M2 IN1: IC2.11 (IN1), J1.5
M2 IN2: IC2.12 (IN2), J1.6
M2 OUT1: IC2.1 (OUT1_1), IC2.2 (OUT1_2), IC2.3 (OUT1_3), Motor2.1
M2 OUT2: IC2.6 (OUT2_1), IC2.7 (OUT2_2), IC2.8 (OUT2_3), Motor2.2
M3 IN1: IC3.11 (IN1), J1.3
M3 IN2: IC3.12 (IN2), J1.4
M3 OUT1: IC3.1 (OUT1_1), IC3.2 (OUT1_2), IC3.3 (OUT1_3), Motor3.1
M3 OUT2: IC3.6 (OUT2_1), IC3.7 (OUT2_2), IC3.8 (OUT2_3), Motor3.2
M4 IN1: IC4.11 (IN1), J1.1
M4 IN2: IC4.12 (IN2), J1.2
M4 OUT1: IC4.1 (OUT1_1), IC4.2 (OUT1_2), IC4.3 (OUT1_3), Motor4.1
M4 OUT2: IC4.6 (OUT2_1), IC4.7 (OUT2_2), IC4.8 (OUT2_3), Motor4.2
unnamed: D1.1 (K), R17.1
unnamed: IC1.20 (VREF), R1.2, R2.1
unnamed: IC2.20 (VREF), R3.2, R4.1
unnamed: IC3.20 (VREF), R5.2, R6.1
unnamed: IC4.20 (VREF), R7.2, R8.1
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, D1.2 (A), IC1.24 (VCC_1), IC1.25 (VCC_2), IC1.26 (VCC_3), IC2.24 (VCC_1), IC2.25 (VCC_2), IC2.26 (VCC_3), IC3.24 (VCC_1), IC3.25 (VCC_2), IC3.26 (VCC_3), IC4.24 (VCC_1), IC4.25 (VCC_2), IC4.26 (VCC_3), J2.1

Notes on the sheet:
モーター用コンデンサー
モーター出力コネクタ
コネクタ類
通電確認用LED
モタドラIC

Board: 2 copper layers, 70.4 x 31.7 mm, 30 parts (6 on the bottom side), 24 nets.

File 2025中/MOTOR Driver/Motor Driver V1.2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4",293D157X9016D2TE3,4,150uF,
"C5, C6, C7, C8",0603,4,0.1uF,
D1,0603,1,LED,
"IC1, IC2, IC3, IC4",BD63150AFM-E2,4,BD63150AFM-E2,
J1,FFC conector 0.5mm Pich,1,Conn_01x08_Pin,
J2,JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,1,Conn_01x03_Pin,
"MOTOR1, MOTOR2, MOTOR3, MOTOR4",JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,4,Conn_01x02_Pin,
"R1, R3, R5, R7",0603,4,1.2k,
R17,0603,1,150,
"R2, R4, R6, R8",0603,4,1k,

## KiCad design 2025後/LINESensor/LinesensorV1.1/LINESensorV1.1.kicad_pcb

Parts:
C1, C2, C9, C13, C14, C15: 0.1uF; C_0603_1608Metric
C3, C6: 0.1μF; C_0603_1608Metric
C5: 100uF; C_1206_3216Metric
C7, C30, C31, C32, C33, C34: 0.1uF; C_0402_1005Metric
C8, C12: 0.1μF; C_0402_1005Metric
C10: 1000uF; CAP_J-V_10X10P5_RUB
D0, D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D27: LED; LED_0603_1608Metric
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x04_Pin; PinSocket_1x04_P2.54mm_Vertical
J2: Conn_01x04_Pin; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 22k; R_0603_1608Metric
R2, R6, R58: 150; R_0402_1005Metric
R3, R4: 5.1kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 10kΩ; R_0603_1608Metric
R7, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69: 50; R_0603_1608Metric
R8, R9: 22; R_0603_1608Metric
R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56: 4.7k; R_0603_1608Metric
R57: 470; R_0603_1608Metric
SIDE1, SIDE2, SIDE3, SIDE4: Conn_01x04_Pin; PinSocket_1x04_P2.54mm_Vertical
SW1: SW_MEC_5G; Reset switch
T0, T1, T2, T3, T4, T5, T6, T7, T8, T9, T10, T11, T12, T13, T14, T15, T16, T17, T18, T19, T20, T21, T22, T23: B19H1LS; LED_0603_1608Metric
Type-C1: 5077CR-16SMC2-BK-TR; NELTRON_5077CR-16SMC2-BK-TR; PARTREV B
U1: ATmega2560-16A; TQFP-100_14x14mm_P0.5mm
U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13: LM393; D0008A-IPC_A
U14: CH340E; MSOP-10_3x3mm_P0.5mm
U15: ADM3202ARUZ-REEL7; RU_16_ADI
Y2: CSTNE16M0V530000R0; OSC_CSTCE16M0V53-R0; PARTREV 10/24/2022

Connections:
+5V: C1.2, C2.2, C3.1, C5.1, C9.2, C12.2, C13.2, C14.2, C15.1, C32.1, C34.1, D0.2 (A), D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), J2.1, R5.1, R6.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.1, R45.1, R46.1, R47.1, R48.1, R49.1, R50.1, R51.1, R52.1, R53.1, R54.1, R55.1, R56.1, SIDE1.2, SIDE2.2, SIDE3.2, SIDE4.2, T0.2 (A), T1.2 (A), T2.2 (A), T3.2 (A), T4.2 (A), T5.2 (A), T6.2 (A), T7.2 (A), T8.2 (A), T9.2 (A), T10.2 (A), T11.2 (A), T12.2 (A), T13.2 (A)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
C1+: C30.2, U15.1 (C1+)
C1-: C30.1, U15.3 (C1-)
C2+: C31.2, U15.4 (C2+)
C2-: C31.1, U15.5 (C2-)
CH340E D+: R8.1, U14.1 (UD+)
CH340E D-: R9.1, U14.2 (UD-)
CH340E RX: U1.3 (PE1), U14.9 (RXD)
CH340E TX: U1.2 (PE0), U14.8 (TXD)
GND: C1.1, C2.1, C5.2, C7.1, C8.2, C9.1, C10.2, C12.1, C13.1, C14.1, C15.2, C33.1, C34.2, D24.1 (K), D25.1 (K), D27.1 (K), J2.2, R1.2, R3.1, R4.2, R7.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2, SIDE1.3, SIDE2.3, SIDE3.3, SIDE4.3, SW1.1 (A), SW1.2 (A), Type-C1.A1_B12 (GND), Type-C1.B1_A12 (GND), Type-C1.S1 (SHIELD), Type-C1.S2 (SHIELD), Type-C1.S3 (SHIELD), Type-C1.S4 (SHIELD), U1.11 (GND), U1.32 (GND), U1.62 (GND), U1.81 (GND), U1.99 (Vcap), U2.4 (V-), U3.4 (V-), U4.4 (V-), U5.4 (V-), U6.4 (V-), U7.4 (V-), U8.4 (V-), U9.4 (V-)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
LINE16: R25.1, T16.1 (K), U10.5 (+)
LINE 0: R1.1, T0.1 (K), U2.5 (+)
LINE 1: R10.1, T1.1 (K), U2.3 (+)
LINE 2: R11.1, T2.1 (K), U3.5 (+)
LINE 3: R12.1, T3.1 (K), U3.3 (+)
LINE 4: R13.1, T4.1 (K), U4.5 (+)
LINE 5: R14.1, T5.1 (K), U4.3 (+)
LINE 6: R15.1, T6.1 (K), U5.5 (+)
LINE 7: R16.1, T7.1 (K), U5.3 (+)
LINE 8: R17.1, T8.1 (K), U6.5 (+)
LINE 9: R18.1, T9.1 (K), U6.3 (+)
LINE 10: R19.1, T10.1 (K), U7.5 (+)
LINE 11: R20.1, T11.1 (K), U7.3 (+)
LINE 12: R21.1, T12.1 (K), U8.5 (+)
LINE 13: R22.1, T13.1 (K), U8.3 (+)
LINE 14: R23.1, T14.1 (K), U9.5 (+)
LINE 15: R24.1, T15.1 (K), U9.3 (+)
LINE 17: R26.1, T17.1 (K), U10.3 (+)
LINE 18: R27.1, T18.1 (K), U11.5 (+)
LINE 19: R28.1, T19.1 (K), U11.3 (+)
LINE 20: R29.1, T20.1 (K), U12.5 (+)
LINE 21: R30.1, T21.1 (K), U12.3 (+)
LINE 22: R31.1, T22.1 (K), U13.5 (+)
LINE 23: R32.1, T23.1 (K), U13.3 (+)
LINE OUT 0: R34.2, U1.82 (PK7), U2.7
LINE OUT 1: R33.2, U1.83 (PK6), U2.1
LINE OUT 2: R36.2, U1.84 (PK5), U3.7
LINE OUT 3: R35.2, U1.85 (PK4), U3.1
LINE OUT 4: R38.2, U1.87 (PK2), U4.7
LINE OUT 5: R37.2, U1.88 (PK1), U4.1
LINE OUT 6: R40.2, U1.89 (PK0), U5.7
LINE OUT 7: R39.2, U1.90 (PF7), U5.1
LINE OUT 8: R42.2, U1.91 (PF6), U6.7
LINE OUT 9: R41.2, U1.92 (PF5), U6.1
LINE OUT 10: R44.2, U1.93 (PF4), U7.7
LINE OUT 11: R43.2, U1.94 (PF3), U7.1
LINE OUT 12: R46.2, U1.55 (PC2), U8.7
LINE OUT 13: R45.2, U1.56 (PC3), U8.1
LINE OUT 14: R48.2, U1.57 (PC4), U9.7
LINE OUT 15: R47.2, U1.58 (PC5), U9.1
LINE OUT 16: R50.2, U1.59 (PC6), U10.7
LINE OUT 17: R49.2, U1.60 (PC7), U10.1
LINE OUT 18: R52.2, U1.63 (PJ0), U11.7
LINE OUT 19: R51.2, U1.64 (PJ1), U11.1
LINE OUT 20: R54.2, U1.65 (PJ2), U12.7
LINE OUT 21: R53.2, U1.66 (PJ3), U12.1
LINE OUT 22: R56.2, U1.67 (PJ4), U13.7
LINE OUT 23: R55.2, U1.68 (PJ5), U13.1
LINE Side 1: SIDE1.1, U1.54 (PC1)
LINE Side 2: SIDE2.1, U1.53 (PC0)
LINE Side 3: SIDE3.1, U1.86 (PK3)
LINE Side 4: SIDE4.1, U1.95 (PF2)
MISO: J1.3, U1.22 (PB3)
MOSI: J1.2, U1.21 (PB2)
unnamed: D0.1 (K), D1.1 (K), R7.1
unnamed: D2.1 (K), D3.1 (K), R59.1
unnamed: D4.1 (K), D5.1 (K), R60.1
unnamed: D6.1 (K), D7.1 (K), R61.1
unnamed: D8.1 (K), D9.1 (K), R62.1
unnamed: D10.1 (K), D11.1 (K), R63.1
unnamed: D12.1 (K), D13.1 (K), R64.1
unnamed: D14.1 (K), D15.1 (K), R65.1
unnamed: D16.1 (K), D17.1 (K), R66.1
unnamed: D18.1 (K), D19.1 (K), R67.1
unnamed: D20.1 (K), D21.1 (K), R68.1
unnamed: D22.1 (K), D23.1 (K), R69.1
unnamed: D24.2 (A), R6.2
unnamed: D25.2 (A), R58.1
unnamed: D27.2 (A), R2.2
unnamed: R3.2, Type-C1.A5 (CC1)
unnamed: R4.1, Type-C1.B5 (CC2)
unnamed: C3.2, U1.98 (AREF)
unnamed: R2.1, U1.26 (PB7)
unnamed: R58.2, U14.6 (TNOW)
unnamed: C8.1, U14.10 (V3)
unnamed: C6.1, U14.4 (~RTS)
RESET: C6.2, J1.4, R5.2, SW1.3 (B), SW1.4 (B), U1.30 (~RESET)
RX-12V: J2.4, U15.13 (R1IN)
RX-MAIN: U1.12 (PH0), U15.12 (R1OUT)
SCK: J1.1, U1.20 (PB1)
TX-12V: J2.3, U15.14 (T1OUT)
TX-MAIN: U1.13 (PH1), U15.11 (T1IN)
Threshold PWM: R57.1, U1.5 (PE3)
Threshold V: C7.2, C10.1, R57.2, SIDE1.4, SIDE2.4, SIDE3.4, SIDE4.4, U2.2 (-), U2.6 (-), U3.2 (-), U3.6 (-), U4.2 (-), U4.6 (-), U5.2 (-), U5.6 (-), U6.2 (-), U6.6 (-), U7.2 (-), U7.6 (-), U8.2 (-), U8.6 (-), U9.2 (-), U9.6 (-), U10.2 (-), U10.6 (-), U11.2 (-), U11.6 (-), U12.2 (-), U12.6 (-), U13.2 (-), U13.6 (-)
Type-C D+: R8.2, Type-C1.A6 (DP1), Type-C1.B6 (DP2)
Type-C D-: R9.2, Type-C1.A7 (DN1), Type-C1.B7 (DN2)
V+: C32.2, U15.2 (V+)
V-: C33.2, U15.6 (V-)
XTAL1: U1.34 (XTAL1), Y2.3
XTAL2: U1.33 (XTAL2), Y2.1

Notes on the sheet:
LED
コネクタ類
Side LINE Sensor
コンパレータ―（LM393BIDR）
RS232Cレベル変換回路
Line Sensor USB
マイコン
ラインセンサー素子（B19H1LS）

Board: 4 copper layers, 120.0 x 128.5 mm, 165 parts (104 on the bottom side), 100 nets.

## Commit log

2025-10-26 README update
2025-10-26 README update
2025-10-30 定期更新
