# Repository kataoka95/KiCad-Print-Circuit-Board-date-buck-up (continued)

## KiCad design 2025中/BALL Sensor/BALL Sensor V1.2/BALL Sensor V1.1.kicad_pcb

Parts:
A0, A1, A2, A3, A4, A5, A6, A7, A8, A9, A10, A11, A12, A13, A14, A15: TSSP4038; PARTREV 2.3
D18: SS14; D_SMA
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J2: Conn_01x09_Pin; PinHeader_1x09_P2.54mm_Vertical
J3: Conn_02x04_Odd_Even; PinSocket_2x04_P2.54mm_Vertical
U1: XIAO ESP32 S3; XIAO-ESP32S3-DIP
U2: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm

Connections:
+3.3V: A0.3 (VS), A1.3 (VS), A2.3 (VS), A3.3 (VS), A4.3 (VS), A5.3 (VS), A6.3 (VS), A7.3 (VS), A8.3 (VS), A9.3 (VS), A10.3 (VS), A11.3 (VS), A12.3 (VS), A13.3 (VS), A14.3 (VS), A15.3 (VS), U1.12 (VCC_3V3), U2.24 (VCC)
+5V: D18.2 (A), J3.5
Ball0: A0.1 (OUT), U2.16 (I15)
Ball1: A1.1 (OUT), U2.17 (I14)
Ball2: A2.1 (OUT), U2.18 (I13)
Ball3: A3.1 (OUT), U2.19 (I12)
Ball4: A4.1 (OUT), U2.23 (I8)
Ball5: A5.1 (OUT), U2.22 (I9)
Ball6: A6.1 (OUT), U2.21 (I10)
Ball7: A7.1 (OUT), U2.20 (I11)
Ball8: A8.1 (OUT), U2.5 (I4)
Ball9: A9.1 (OUT), U2.4 (I5)
Ball10: A10.1 (OUT), U2.3 (I6)
Ball11: A11.1 (OUT), U2.2 (I7)
Ball12: A12.1 (OUT), U2.6 (I3)
Ball13: A13.1 (OUT), U2.7 (I2)
Ball14: A14.1 (OUT), U2.8 (I1)
Ball15: A15.1 (OUT), U2.9 (I0)
COM: U1.11 (D10), U2.1 (COM)
GND: A0.2 (GND), A1.2 (GND), A2.2 (GND), A3.2 (GND), A4.2 (GND), A5.2 (GND), A6.2 (GND), A7.2 (GND), A8.2 (GND), A9.2 (GND), A10.2 (GND), A11.2 (GND), A12.2 (GND), A13.2 (GND), A14.2 (GND), A15.2 (GND), J3.1, U1.13 (GND), U2.12 (GND), U2.15 (~E)
unnamed: D18.1 (K), U1.14 (VUSB)
RX_Ball: J3.8, U1.8 (D7)
S0: U1.10 (D9), U2.10 (S0)
S1: U1.9 (D8), U2.11 (S1)
S2: U1.5 (D4), U2.14 (S2)
S3: U1.6 (D5), U2.13 (S3)
TX_Ball: J3.6, U1.7 (D6)

Notes on the sheet:
マルチプレクサ回路（CD74HC4067SM）
XIAO ESP32 S3
ボールセンサー素子（TSSP4038）

Board: 2 copper layers, 100.0 x 100.0 mm, 25 parts (2 on the bottom side), 27 nets.

File 2025中/BALL Sensor/BALL Sensor V1.2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"A0, A1, A10, A11, A12, A13, A14, A15, A2, A3, A4, A5, A6, A7, A8, A9",TSSP4038,16,TSSP4038,
D18,D_SMA,1,SS14,
J2,PinHeader_1x09_P2.54mm_Vertical,1,Conn_01x09_Pin,
J3,PinSocket_2x04_P2.54mm_Vertical,1,Conn_02x04_Odd_Even,
U1,XIAO-ESP32S3-DIP,1,XIAO ESP32 S3,
U2,SSOP-24_5.3x8.2mm_P0.65mm,1,CD74HC4067SM,

## KiCad design 2025中/POWER/Power V1.2/Power V1.1.kicad_pcb

Parts:
C2, C3: 1uF; C_0805_2012Metric
C8: 100uF; CP_Radial_D6.3mm_P2.50mm
C9: 1000uF; CAP_J-V_10X10P5_RUB
C12, C13: 0.1uF; C_0603_1608Metric
D2: LED; LED_0603_1608Metric
D3, D4: GS1010FL; Nexperia_CFP3_SOD-123W
F1: Fuse; Fuseholder_Clip-5x20mm_Keystone_3517_Inline_P23.11x6.76mm_D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
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Pin; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J2: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
J4: Conn_01x01_Pin; JLCPCB
KICK1: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
L1: CSAB1260A; L_Changjiang_FXL1360
LINE1: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
MAIN1: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
MD1: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
R4: 150; R_0603_1608Metric
R5: 47k; R_0603_1608Metric
SW1: SW_SPST; DS-850K-S-ON
U1: LM2576SX-5.0_NOPB
U3: ADP3338AKCZ-3.3; DigiKey_Part_Number ADP3338AKCZ-3.3-RLCT-ND

Connections:
+3.3V: C3.1, D4.2 (A), LINE1.2, MAIN1.2, MD1.2, U3.2 (OUT), U3.4 (OUT)
+5V: C2.1, C9.1, D4.1 (K), L1.2, LINE1.1, MAIN1.1, R4.1, U1.4 (FB), U3.3 (IN)
+12V: C8.1, C12.1, C13.1, F1.2, J2.1, KICK1.1, MD1.1, U1.1 (VIN)
GND: C2.2, C3.2, C8.2, C9.2, C12.2, D2.1 (K), D3.2 (A), J1.2, J2.2, KICK1.2, LINE1.3, MAIN1.3, MD1.3, R5.2, U1.3 (GND), U1.6 (GND__1), U3.1 (GND)
unnamed: D2.2 (A), R4.2
unnamed: D3.1 (K), L1.1, U1.2 (OUT)
unnamed: J1.1, SW1.1 (A)
unnamed: F1.1, SW1.2 (B)
unnamed: C13.2, R5.1, U1.5 (ON/OFF)

Notes on the sheet:
+3.3Vレギュレータ―
外部出力コネクタ
+5V生成（LM2576SX-5.0_NOPB）
Battry

Board: 2 copper layers, 72.8 x 38.9 mm, 25 parts (11 on the bottom side), 9 nets.

File 2025中/POWER/Power V1.2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C12, C13",0603,2,0.1uF,
"C2, C3",0805,2,1uF,
C8,CP_Radial_D6.3mm_P2.50mm,1,100uF,
C9,CAP_J-V_10X10P5_RUB,1,1000uF,
D2,0603,1,LED,
"D3, D4",Nexperia_CFP3_SOD-123W,2,GS1010FL,
F1,Fuseholder_Clip-5x20mm_Keystone_3517_Inline_P23.11x6.76mm_D1.70mm_Horizontal,1,Fuse,
J1,AMASS_XT30U-F_1x02_P5.0mm_Vertical,1,Conn_01x02_Pin,
J2,PinSocket_1x02_P2.54mm_Vertical,1,Conn_01x02_Pin,
J4,JLCPCB,1,Conn_01x01_Pin,
KICK1,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,Conn_01x02_Pin,
L1,L_Changjiang_FXL1360,1,CSAB1260A,
"LINE1, MAIN1, MD1",JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,3,Conn_01x03_Pin,
R4,0603,1,150,
R5,0603,1,47k,
SW1,DS-850K-S-ON,1,SW_SPST,
U1,LM2576SX-5.0_NOPB,1,LM2576SX-5.0_NOPB,
U3,ADP3338AKCZ-3.3,1,ADP3338AKCZ-3.3,

## KiCad design 2025中/BALL Sensor/BALL Sensor V1.1/BALL Sensor V1.1.kicad_pcb

Parts:
A1, A2, A3, A4, A5, A6, A7, A8, A9, A10, A11, A12, A13, A14, A15, A16: TSSP4038; PARTREV 2.3
C1: 1uF; C_0603_1608Metric
C4, C5, C6, C25: 0.1uF; C_0603_1608Metric
C8: 4.7uF; C_0603_1608Metric
C35: 100uF; C_1206_3216Metric
C36: 47uF; C_0603_1608Metric
D17, D21: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J2: Conn_01x05_Pin; PinSocket_1x05_P2.54mm_Vertical
R1: 10k; R_0603_1608Metric
R4: 100; R_0603_1608Metric
R5, R6: 22Ω; R_0603_1608Metric
R7: 10kΩ; R_0603_1608Metric
R8, R9: 5.1kΩ; R_0603_1608Metric
R11: 150Ω; R_0603_1608Metric
SW2: SW_MEC_5G; Reset switch
Type-C1: 5077CR-16SMC2-BK-TR; NELTRON_5077CR-16SMC2-BK-TR; PARTREV B
U2: ATmega32U4-A; TQFP-44_10x10mm_P0.8mm
Y1: CSTCE16M0V53-R0; OSC_CSTCE16M0V53-R0; PARTREV 10/24/2022

Connections:
+5V: A1.3 (VS), A2.3 (VS), A3.3 (VS), A4.3 (VS), A5.3 (VS), A6.3 (VS), A7.3 (VS), A8.3 (VS), A9.3 (VS), A10.3 (VS), A11.3 (VS), A12.3 (VS), A13.3 (VS), A14.3 (VS), A15.3 (VS), A16.3 (VS), C4.2, C5.2, C6.2, C8.2, C25.1, C35.1, C36.1, J1.5, R7.1, R11.1, U2.2 (UVCC), U2.7 (VBUS), U2.14 (VCC), U2.24 (AVCC), U2.34 (VCC), U2.44 (AVCC)
Ball1: A1.1 (OUT), U2.26 (PD6)
Ball2: A2.1 (OUT), U2.27 (PD7)
Ball3: A3.1 (OUT), U2.28 (PB4)
Ball4: A4.1 (OUT), U2.29 (PB5)
Ball5: A5.1 (OUT), U2.30 (PB6)
Ball6: A6.1 (OUT), U2.36 (PF7)
Ball7: A7.1 (OUT), U2.37 (PF6)
Ball8: A8.1 (OUT), U2.38 (PF5)
Ball9: A9.1 (OUT), U2.39 (PF4)
Ball10: A10.1 (OUT), U2.40 (PF1)
Ball11: A11.1 (OUT), U2.8 (PB0)
Ball12: A12.1 (OUT), J2.5, U2.9 (PB1)
Ball13: A13.1 (OUT), J2.4, U2.10 (PB2)
Ball14: A14.1 (OUT), J2.3, U2.11 (PB3)
Ball15: A15.1 (OUT), U2.19 (PD1)
Ball16: A16.1 (OUT), U2.22 (PD5)
D+_Ballusb1: R5.1, U2.4 (D+)
D+_Ballusb2: R5.2, Type-C1.A6 (DP1), Type-C1.B6 (DP2)
D-_Ballusb1: R6.1, U2.3 (D-)
D-_Ballusb2: R6.2, Type-C1.A7 (DN1), Type-C1.B7 (DN2)
GND: A1.2 (GND), A2.2 (GND), A3.2 (GND), A4.2 (GND), A5.2 (GND), A6.2 (GND), A7.2 (GND), A8.2 (GND), A9.2 (GND), A10.2 (GND), A11.2 (GND), A12.2 (GND), A13.2 (GND), A14.2 (GND), A15.2 (GND), A16.2 (GND), C1.2, C4.1, C5.1, C6.1, C8.1, C25.2, C35.2, C36.2, D17.1 (K), D21.1 (K), J1.7, J2.1, R1.2, R8.1, R9.2, SW2.1 (A), SW2.2 (A), Type-C1.A1_B12 (GND), Type-C1.B1_A12 (GND), Type-C1.S1 (SHIELD), Type-C1.S2 (SHIELD), Type-C1.S3 (SHIELD), Type-C1.S4 (SHIELD), U2.5 (UGND), U2.15 (GND), U2.23 (GND), U2.35 (GND), U2.43 (GND), Y1.2
unnamed: D17.2 (A), R11.2
unnamed: D21.2 (A), R4.2
unnamed: R8.2, Type-C1.A5 (CC1)
unnamed: R9.1, Type-C1.B5 (CC2)
unnamed: R4.1, U2.32 (PC7)
unnamed: C1.1, U2.6 (UCAP)
unnamed: R1.1, U2.33 (~HWB/PE2)
RX_Ball: J1.3, U2.20 (PD2)
SPI_RESET: J2.2, R7.2, SW2.3 (B), SW2.4 (B), U2.13 (~RESET)
TX_Ball: J1.1, U2.21 (PD3)
XTAL1: U2.17 (XTAL1), Y1.1
XTAL2: U2.16 (XTAL2), Y1.3

Notes on the sheet:
Green
ネオピクの直前
Blue
マイコンの安定動作用
ATmega32u4マイコン
BallSensor USB-C
ボールセンサー素子（TSSP4038）

Board: 2 copper layers, 100.0 x 100.0 mm, 44 parts (12 on the bottom side), 34 nets.

File 2025中/BALL Sensor/BALL Sensor V1.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"A1, A10, A11, A12, A13, A14, A15, A16, A2, A3, A4, A5, A6, A7, A8, A9",TSSP4038,16,TSSP4038,
C1,0603,1,1uF,
"C25, C4, C5, C6",0603,4,0.1uF,
C35,1206,1,100uF,
C36,0603,1,47uF,
C8,0603,1,4.7uF,
"D17, D21",0603,2,LED,
J1,PinHeader_2x04_P2.54mm_Vertical,1,Conn_02x04_Odd_Even,
J2,PinSocket_1x05_P2.54mm_Vertical,1,Conn_01x05_Pin,
R11,0603,1,150Ω,
R4,0603,1,100,
"R5, R6",0603,2,22Ω,
R7,0603,1,10kΩ,
"R8, R9",0603,2,5.1kΩ,
SW2,Reset switch,1,SW_MEC_5G,
TYPE-C1,NELTRON_5077CR-16SMC2-BK-TR,1,5077CR-16SMC2-BK-TR,
U2,TQFP-44_10x10mm_P0.8mm,1,ATmega32U4-A,
Y1,OSC_CSTCE16M0V53-R0,1,CSTCE16M0V53-R0,
