# Repository kataoka95/KiCad-Print-Circuit-Board-date-buck-up

File README.md:

# KiCad-Print-Circuit-Board-date-buck-up
このリポジトリにはVEGAの回路データが入っています。
回路データを確認するには、お使いのパソコンにKiCADをインストールし、確認したい回路が設計された時期のファイルを開き、（2025前など）確認したい回路のファイルを開きます（Ball Sensorなど）そして拡張子が ".kicad_pro" のものをクリックし、KiCADで回路データのファイルを開いてください。
回路図を確認したい場合は、回路図エディターを、基板データを確認したい場合は、PCBエディターを開いてください。
> © 2025 Kataoka Akihiro

## KiCad design 2025中/MAIN/MAIN V1.3/MAIN V1.2.kicad_pcb

Parts:
A1: TEENSY4.1
BZ1: Buzzer; Buzzer UDX01CLFPH
C1, C26: 0.1μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10: 100uF; CP_Radial_D6.3mm_P2.50mm
C11: 10uF; C_0603_1608Metric
C12: 0.1uF; C_0603_1608Metric
Camera1, Camera2: Conn_01x04_Pin; GROVE-HW4-2.0
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D19, D20, D21, D22, D23, D24, D25: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D18: SS14; D_SMA
Gyro1: Conn_01x08_Pin; BNO055
J1: Conn_02x04_Odd_Even; PinSocket_2x04_P2.54mm_Vertical
J2: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: Conn_01x09_Pin; PinSocket_1x09_P2.54mm_Vertical
J4: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
J5: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: Conn_01x08_Pin; FFC conector 0.5mm Pich
Q1: BSS138; SOT-23
R1, R10: 10k; R_0402_1005Metric
R5, R6, R7, R12, R13, R14: 1kΩ; R_0603_1608Metric
R8, R9: 5.1k; R_0603_1608Metric
TACT1, TACT2, TACT3: SW_MEC_5G; Big tact switch MAIN
ToggleSwitch1: Conn_01x03_Pin; PinSocket_1x03_P2.54mm_Vertical
Type-C1: Type-C moodule omote
U1: XIAO ESP32 S3; XIAO-ESP32S3-DIP
monitor1: Conn_01x04_Pin; SSD1306 (akizuki)

Connections:
+3.3V: A1.3V3 (3.3V), A1.3V3@2 (3.3V), A1.3V3@3 (3.3V), C1.1, C26.1, Gyro1.1, J2.2, Q1.1 (G), R5.2, R6.2, R7.1, R10.1, R12.1, R13.1, R14.1, U1.12 (VCC_3V3), monitor1.3
+5V: A1.VIN, C10.1, C11.1, C12.1, Camera1.3, Camera2.3, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), D17.1 (VDD), D18.2 (A), D19.1 (VDD), D20.1 (VDD), D21.1 (VDD), D22.1 (VDD), D23.1 (VDD), D24.1 (VDD), D25.1 (VDD), J1.3, J2.1, R1.1
A: A1.D35
B: A1.D36
Buzzer: A1.D23 (A9), BZ1.1 (+)
C: A1.D37
Cam1 RX: A1.D0 ((CRX1)D0), Camera1.2
Cam1 TX: A1.D1 ((CTX1)D1), Camera1.1
Cam2 RX: A1.D7, Camera2.2
Cam2 TX: A1.D8, Camera2.1
Ctrl SW1: A1.D30
D8: U1.9 (D8)
GND: A1.AGND/GND (GND), A1.GND, A1.GND@2 (GND), BZ1.2 (-), C1.2, C10.2, C11.2, C12.2, C26.2, Camera1.4, Camera2.4, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), D17.3 (VSS), D19.3 (VSS), D20.3 (VSS), D21.3 (VSS), D22.3 (VSS), D23.3 (VSS), D24.3 (VSS), D25.3 (VSS), Gyro1.2, J1.7, J2.3, R8.2, R9.2, TACT1.3 (B), TACT1.4 (B), TACT2.3 (B), TACT2.4 (B), TACT3.3 (B), TACT3.4 (B), ToggleSwitch1.2, Type-C1.4 (GND), Type-C1.7 (GND), U1.13 (GND), monitor1.4
Gyro-SCL: A1.D19 (A5), Gyro1.4, R5.1
Gyro-SDA: A1.D18 (A4), Gyro1.3, R6.1
M1 EN: A1.D5, J6.3
M1 PH: A1.D6, J6.4
M2 EN: A1.D3, J6.1
M2 PH: A1.D4, J6.2
M3 EN: A1.D11 ((SDO)D11), J6.7
M3 PH: A1.D12 ((SDI)D12), J6.8
M4 EN: A1.D9, J6.5
M4 PH: A1.D10 ((CS)D10), J6.6
NeoPixel A0: D1.4 (DIN), D13.4 (DIN), D22.4 (DIN), Q1.3 (D), R1.2
NeoPixel ESP A0: Q1.2 (S), R10.2, U1.1 (D0)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)
unnamed: D16.2 (DOUT), D17.4 (DIN)
unnamed: D17.2 (DOUT), D19.4 (DIN)
unnamed: D18.1 (K), U1.14 (VUSB)
unnamed: D19.2 (DOUT), D20.4 (DIN)
unnamed: D20.2 (DOUT), D21.4 (DIN)
unnamed: D22.2 (DOUT), D23.4 (DIN)
unnamed: D23.2 (DOUT), D24.4 (DIN)
unnamed: D24.2 (DOUT), D25.4 (DIN)
unnamed: R8.1, Type-C1.5 (CC1)
unnamed: R9.1, Type-C1.6 (CC2)
RX_Ball 3.3V: A1.D28, J1.2
RX_ESP: U1.8 (D7)
SCL(monitor): U1.6 (D5), monitor1.2
SDA(monitor): U1.5 (D4), monitor1.1
SW1: A1.D32, R12.2, TACT1.1 (A), TACT1.2 (A)
SW2: A1.D31, R13.2, TACT2.1 (A), TACT2.2 (A)
SW3: A1.D34, R14.2, TACT3.1 (A), TACT3.2 (A)
TOGGLE1: A1.D33, R7.2, ToggleSwitch1.3
TX_Ball 3.3V: A1.D29, J1.4
TX_ESP: U1.7 (D6)
Teensy4.1_D+: J4.1, Type-C1.3 (D+)
Teensy4.1_D-: J4.2, Type-C1.2 (D-)
X1: A1.D38 (A14)
X2: A1.D39 (A15)
X3: A1.D40 (A16)

Notes on the sheet:
XIAO ESP32 S3
ボールセンサーの信号入力（RX,TXの変換措置はここで）
スイッチ類
カメラ用コネクタ（TX,RX逆転処置はここで、）
monitor
ラインセンサーコネクタ
NeoPixel
Teensy4.1
ジャイロ（BNO055）
電源コネクタ
ブザー
Teensy TYPE-C
モタドラ基板通信用コネクタ

Board: 2 copper layers, 100.0 x 119.0 mm, 59 parts (6 on the bottom side), 54 nets.

File 2025中/MAIN/MAIN V1.4/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
A1,TEENSY4.1,1,TEENSY4.1,
BZ1,Buzzer UDX01CLFPH,1,Buzzer,
"C1, C26",0603,2,0.1μF,
C10,CP_Radial_D6.3mm_P2.50mm,1,100uF,
C11,0603,1,10uF,
C12,0603,1,0.1uF,
"CAMERA1, CAMERA2",GROVE-HW4-2.0,2,Conn_01x04_Pin,
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D3, D4, D5, D6, D7, D8, D9",LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,24,WS2812B,
D25,D_SMA,1,SS14,
GYRO1,BNO055,1,Conn_01x08_Pin,
J1,PinSocket_2x04_P2.54mm_Vertical,1,Conn_02x04_Odd_Even,
J2,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,1,Conn_01x03_Pin,
J3,PinSocket_1x09_P2.54mm_Vertical,1,Conn_01x09_Pin,
J4,PinSocket_1x02_P2.54mm_Vertical,1,Conn_01x02_Pin,
"J5, J7, J8",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,3,Conn_01x02_Pin,
J6,FFC conector 0.5mm Pich,1,Conn_01x08_Pin,
MONITOR1,SSD1306 (akizuki),1,Conn_01x04_Pin,
Q1,SOT-23,1,BSS138,
"R1, R10",0402,2,10k,
"R12, R13, R14, R5, R6, R7",0603,6,1kΩ,
R2,0805,1,100k,
R3,0603,1,100,
"R8, R9",0603,2,5.1k,
ROGO1,JLCPCB Big,1,Conn_01x01_Pin,
"TACT1, TACT2, TACT3",Big tact switch MAIN,3,SW_MEC_5G,
TOGGLESWITCH1,PinSocket_1x03_P2.54mm_Vertical,1,Conn_01x03_Pin,
TYPE-C1,Type-C moodule omote,1,~,
U1,XIAO-ESP32S3-DIP,1,XIAO ESP32 S3,

## KiCad design 2025中/LINESensor/LINE Sensor V1.3/LINE Sensor V1.1.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: LED; LED_0603_1608Metric
D25: SS14; D_SMA
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J2: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
MUX1, MUX2, MUX3: HEF4051BTT; TSSOP-16_4.4x5mm_P0.65mm
R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 100k; R_0603_1608Metric
R7, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69: 50; R_0603_1608Metric
T0, T1, T2, T3, T4, T5, T6, T7, T8, T9, T10, T11, T12, T13, T14, T15, T16, T17, T18, T19, T20, T21, T22, T23: B19H1LS; LED_0603_1608Metric
U1: XIAO ESP32 S3; XIAO-ESP32S3-DIP

Connections:
+3.3V: J1.2, MUX1.16 (VDD), MUX2.16 (VDD), MUX3.16 (VDD), T0.2 (A), T1.2 (A), T2.2 (A), T3.2 (A), T4.2 (A), T5.2 (A), T6.2 (A), T7.2 (A), T8.2 (A), T9.2 (A), T10.2 (A), T11.2 (A), T12.2 (A), T13.2 (A), T14.2 (A), T15.2 (A), T16.2 (A), T17.2 (A), T18.2 (A), T19.2 (A), T20.2 (A), T21.2 (A), T22.2 (A), T23.2 (A)
+5V: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D25.2 (A), J1.1
A: MUX1.11 (A), MUX2.11 (A), MUX3.11 (A), U1.11 (D10)
B: MUX1.10 (B), MUX2.10 (B), MUX3.10 (B), U1.10 (D9)
C: MUX1.9 (C), MUX2.9 (C), MUX3.9 (C), U1.5 (D4)
GND: J1.3, MUX1.6 (Inh), MUX1.7 (VEE), MUX1.8 (VSS), MUX2.6 (Inh), MUX2.7 (VEE), MUX2.8 (VSS), MUX3.6 (Inh), MUX3.7 (VEE), MUX3.8 (VSS), R1.2, R7.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2, U1.13 (GND)
LINE16: MUX3.5 (X5), R25.1, T16.1 (K)
LINE 0: MUX1.5 (X5), R1.1, T0.1 (K)
LINE 1: MUX1.4 (X7), R10.1, T1.1 (K)
LINE 2: MUX1.2 (X6), R11.1, T2.1 (K)
LINE 3: MUX1.1 (X4), R12.1, T3.1 (K)
LINE 4: MUX1.12 (X3), R13.1, T4.1 (K)
LINE 5: MUX1.13 (X0), R14.1, T5.1 (K)
LINE 6: MUX1.14 (X1), R15.1, T6.1 (K)
LINE 7: MUX1.15 (X2), R16.1, T7.1 (K)
LINE 8: MUX2.15 (X2), R17.1, T8.1 (K)
LINE 9: MUX2.14 (X1), R18.1, T9.1 (K)
LINE 10: MUX2.13 (X0), R19.1, T10.1 (K)
LINE 11: MUX2.12 (X3), R20.1, T11.1 (K)
LINE 12: MUX2.5 (X5), R21.1, T12.1 (K)
LINE 13: MUX2.4 (X7), R22.1, T13.1 (K)
LINE 14: MUX2.2 (X6), R23.1, T14.1 (K)
LINE 15: MUX2.1 (X4), R24.1, T15.1 (K)
LINE 17: MUX3.4 (X7), R26.1, T17.1 (K)
LINE 18: MUX3.2 (X6), R27.1, T18.1 (K)
LINE 19: MUX3.1 (X4), R28.1, T19.1 (K)
LINE 20: MUX3.13 (X0), R29.1, T20.1 (K)
LINE 21: MUX3.14 (X1), R30.1, T21.1 (K)
LINE 22: MUX3.15 (X2), R31.1, T22.1 (K)
LINE 23: MUX3.12 (X3), R32.1, T23.1 (K)
unnamed: D1.1 (K), D2.1 (K), R7.1
unnamed: D3.1 (K), D4.1 (K), R59.1
unnamed: D5.1 (K), D6.1 (K), R60.1
unnamed: D7.1 (K), D8.1 (K), R61.1
unnamed: D9.1 (K), D10.1 (K), R62.1
unnamed: D11.1 (K), D12.1 (K), R63.1
unnamed: D13.1 (K), D14.1 (K), R64.1
unnamed: D15.1 (K), D16.1 (K), R65.1
unnamed: D17.1 (K), D18.1 (K), R66.1
unnamed: D19.1 (K), D20.1 (K), R67.1
unnamed: D21.1 (K), D22.1 (K), R68.1
unnamed: D23.1 (K), D24.1 (K), R69.1
unnamed: D25.1 (K), U1.14 (VUSB)
RX_LINE: J2.2, U1.8 (D7)
TX_LINE: J2.1, U1.7 (D6)
X1: MUX1.3 (X), U1.4 (D3)
X2: MUX2.3 (X), U1.6 (D5)
X3: MUX3.3 (X), U1.9 (D8)

Notes on the sheet:
XIAO ESP32 S3
ラインセンサー素子（B19H1LS）
LED
マルチプレクサ回路（HEF4051BTT）

Board: 2 copper layers, 120.0 x 128.5 mm, 94 parts (48 on the bottom side), 48 nets.

File 2025中/LINESensor/LINE Sensor V1.3/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D3, D4, D5, D6, D7, D8, D9",0603,24,LED,
D25,D_SMA,1,SS14,
J1,JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,1,Conn_01x03_Pin,
J2,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,Conn_01x02_Pin,
"MUX1, MUX2, MUX3",TSSOP-16_4.4x5mm_P0.65mm,3,HEF4051BTT,
"R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32",0603,24,100k,
"R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R7",0603,12,50,
"T0, T1, T10, T11, T12, T13, T14, T15, T16, T17, T18, T19, T2, T20, T21, T22, T23, T3, T4, T5, T6, T7, T8, T9",0603,24,B19H1LS,
U1,XIAO-ESP32S3-DIP,1,XIAO ESP32 S3,
