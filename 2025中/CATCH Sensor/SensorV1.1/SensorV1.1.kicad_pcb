# Repository kataoka95/KiCad-Print-Circuit-Board-date-buck-up

## KiCad design 2025中/LINESensor/LINE Sensor V1.1/LINE Sensor V1.1.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: LED; LED_0603_1608Metric
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
MUX1, MUX2, MUX3: HEF4051BTT; TSSOP-16_4.4x5mm_P0.65mm
R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 22k; R_0603_1608Metric
R7, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69: 50; R_0603_1608Metric
T0, T1, T2, T3, T4, T5, T6, T7, T8, T9, T10, T11, T12, T13, T14, T15, T16, T17, T18, T19, T20, T21, T22, T23: B19H1LS; LED_0603_1608Metric
connector1: Conn_01x06_Pin; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal

Connections:
+3.3V: J1.2, MUX1.16 (VDD), MUX2.16 (VDD), MUX3.16 (VDD), T0.2 (A), T1.2 (A), T2.2 (A), T3.2 (A), T4.2 (A), T5.2 (A), T6.2 (A), T7.2 (A), T8.2 (A), T9.2 (A), T10.2 (A), T11.2 (A), T12.2 (A), T13.2 (A), T14.2 (A), T15.2 (A), T16.2 (A), T17.2 (A), T18.2 (A), T19.2 (A), T20.2 (A), T21.2 (A), T22.2 (A), T23.2 (A)
+5V: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), J1.1
A: MUX1.11 (A), MUX2.11 (A), MUX3.11 (A), connector1.1
B: MUX1.10 (B), MUX2.10 (B), MUX3.10 (B), connector1.2
C: MUX1.9 (C), MUX2.9 (C), MUX3.9 (C), connector1.3
GND: J1.3, MUX1.6 (Inh), MUX1.7 (VEE), MUX1.8 (VSS), MUX2.6 (Inh), MUX2.7 (VEE), MUX2.8 (VSS), MUX3.6 (Inh), MUX3.7 (VEE), MUX3.8 (VSS), R1.2, R7.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2
LINE16: MUX3.5 (X5), R25.1, T16.1 (K)
LINE 0: MUX1.5 (X5), R1.1, T0.1 (K)
LINE 1: MUX1.4 (X7), R10.1, T1.1 (K)
LINE 2: MUX1.2 (X6), R11.1, T2.1 (K)
LINE 3: MUX1.1 (X4), R12.1, T3.1 (K)
LINE 4: MUX1.12 (X3), R13.1, T4.1 (K)
LINE 5: MUX1.13 (X0), R14.1, T5.1 (K)
LINE 6: MUX1.14 (X1), R15.1, T6.1 (K)
LINE 7: MUX1.15 (X2), R16.1, T7.1 (K)
LINE 8: MUX2.15 (X2), R17.1, T8.1 (K)
LINE 9: MUX2.14 (X1), R18.1, T9.1 (K)
LINE 10: MUX2.13 (X0), R19.1, T10.1 (K)
LINE 11: MUX2.12 (X3), R20.1, T11.1 (K)
LINE 12: MUX2.5 (X5), R21.1, T12.1 (K)
LINE 13: MUX2.4 (X7), R22.1, T13.1 (K)
LINE 14: MUX2.2 (X6), R23.1, T14.1 (K)
LINE 15: MUX2.1 (X4), R24.1, T15.1 (K)
LINE 17: MUX3.4 (X7), R26.1, T17.1 (K)
LINE 18: MUX3.2 (X6), R27.1, T18.1 (K)
LINE 19: MUX3.1 (X4), R28.1, T19.1 (K)
LINE 20: MUX3.13 (X0), R29.1, T20.1 (K)
LINE 21: MUX3.14 (X1), R30.1, T21.1 (K)
LINE 22: MUX3.15 (X2), R31.1, T22.1 (K)
LINE 23: MUX3.12 (X3), R32.1, T23.1 (K)
unnamed: D1.1 (K), D2.1 (K), R7.1
unnamed: D3.1 (K), D4.1 (K), R59.1
unnamed: D5.1 (K), D6.1 (K), R60.1
unnamed: D7.1 (K), D8.1 (K), R61.1
unnamed: D9.1 (K), D10.1 (K), R62.1
unnamed: D11.1 (K), D12.1 (K), R63.1
unnamed: D13.1 (K), D14.1 (K), R64.1
unnamed: D15.1 (K), D16.1 (K), R65.1
unnamed: D17.1 (K), D18.1 (K), R66.1
unnamed: D19.1 (K), D20.1 (K), R67.1
unnamed: D21.1 (K), D22.1 (K), R68.1
unnamed: D23.1 (K), D24.1 (K), R69.1
X1: MUX1.3 (X), connector1.6
X2: MUX2.3 (X), connector1.5
X3: MUX3.3 (X), connector1.4

Notes on the sheet:
ラインセンサー用コネクタ
ラインセンサー素子（B19H1LS）
LED
マルチプレクサ回路（HEF4051BTT）

Board: 2 copper layers, 120.0 x 128.5 mm, 92 parts (48 on the bottom side), 45 nets.

## KiCad design 2025中/MAIN/MAIN V1.1/MAIN V1.1.kicad_pcb

Parts:
A1: TEENSY4.1
BZ1: Buzzer; Buzzer UDX01CLFPH
C1, C26: 0.1μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10: 100uF; CP_Radial_D6.3mm_P2.50mm
C11: 10uF; C_0603_1608Metric
C12: 0.1uF; C_0603_1608Metric
Camera1, Camera2: Conn_01x04_Pin; GROVE-HW4-2.0
CatchSensor1: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Gyro1: Conn_01x08_Pin; BNO055
J1: Conn_02x04_Odd_Even; PinSocket_2x04_P2.54mm_Vertical
J2: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
J6: Conn_01x08_Pin; FFC conector 0.5mm Pich
KICK1: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
LED1: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
LINE1: Conn_01x06_Pin; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
Q1, Q2: BSS138; SOT-23
R1: 100; R_0603_1608Metric
R2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R4, R10, R11: 10k; R_0603_1608Metric
R5, R6, R7, R12, R13, R14, R15: 1kΩ; R_0603_1608Metric
R16, R17: 5.1kΩ; R_0603_1608Metric
TACT1, TACT2, TACT3: SW_MEC_5G; Big tact switch MAIN
TACT4: SW_MEC_5G; SW_PUSH_6mm
ToggleSwitch1: Conn_01x03_Pin; PinSocket_1x03_P2.54mm_Vertical
Type-C1: 5077CR-16SMC2-BK-TR; NELTRON_5077CR-16SMC2-BK-TR; PARTREV B
monitor1: Conn_01x04_Pin; SSD1306 (akizuki)

Connections:
+3.3V: A1.3V3 (3.3V), A1.3V3@2 (3.3V), A1.3V3@3 (3.3V), C1.1, C26.1, CatchSensor1.1, Gyro1.1, J2.2, Q1.1 (G), Q2.1 (G), R5.2, R6.2, R7.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, monitor1.3
+5V: A1.VIN, C10.1, C11.1, C12.1, Camera1.3, Camera2.3, J1.5, J2.1, R1.2, R3.1, R4.1
A: A1.D35, LINE1.1
B: A1.D36, LINE1.2
Ball Catch Sensor: A1.D20 (A6), CatchSensor1.2, R2.1
Buzzer: A1.D23 (A9), BZ1.1 (+)
C: A1.D37, LINE1.3
Cam1 RX: A1.D0 ((CRX1)D0), Camera1.2
Cam1 TX: A1.D1 ((CTX1)D1), Camera1.1
Cam2 RX: A1.D7, Camera2.2
Cam2 TX: A1.D8, Camera2.1
Ctrl SW1: A1.D30, R15.2, TACT4.1 (A), TACT4.2 (A)
GND: A1.AGND/GND (GND), A1.GND, A1.GND@2 (GND), BZ1.2 (-), C1.2, C10.2, C11.2, C12.2, C26.2, Camera1.4, Camera2.4, Gyro1.2, J1.7, J2.3, KICK1.3, LED1.2, R2.2, R16.1, R17.2, TACT1.3 (B), TACT1.4 (B), TACT2.3 (B), TACT2.4 (B), TACT3.3 (B), TACT3.4 (B), TACT4.3 (B), TACT4.4 (B), ToggleSwitch1.2, Type-C1.A1_B12 (GND), Type-C1.B1_A12 (GND), Type-C1.S1 (SHIELD), Type-C1.S2 (SHIELD), Type-C1.S3 (SHIELD), Type-C1.S4 (SHIELD), monitor1.4
Gyro-SCL: A1.D19 (A5), Gyro1.4, R5.1
Gyro-SDA: A1.D18 (A4), Gyro1.3, R6.1
KICK 1: A1.D22 (A8), KICK1.1
KICK 2: A1.D14 (A0), KICK1.2
M1 EN: A1.D5, J6.3
M1 PH: A1.D6, J6.4
M2 EN: A1.D3, J6.1
M2 PH: A1.D4, J6.2
M3 EN: A1.D11 ((SDO)D11), J6.7
M3 PH: A1.D12 ((SDI)D12), J6.8
M4 EN: A1.D9, J6.5
M4 PH: A1.D10 ((CS)D10), J6.6
unnamed: LED1.1, R1.1
unnamed: R16.2, Type-C1.A5 (CC1)
unnamed: R17.1, Type-C1.B5 (CC2)
RX_Ball 3.3V: A1.D28, Q1.2 (S), R10.2
RX_Ball 5V: J1.1, Q1.3 (D), R3.2
SCL(monitor): A1.D24 (A10), monitor1.2
SDA(monitor): A1.D25 (A11), monitor1.1
SW1: A1.D32, R12.2, TACT1.1 (A), TACT1.2 (A)
SW2: A1.D31, R13.2, TACT2.1 (A), TACT2.2 (A)
SW3: A1.D34, R14.2, TACT3.1 (A), TACT3.2 (A)
TOGGLE1: A1.D33, R7.2, ToggleSwitch1.3
TX_Ball 3.3V: A1.D29, Q2.2 (S), R11.2
TX_Ball 5V: J1.3, Q2.3 (D), R4.2
Teensy4.1_D+: J3.1, Type-C1.A6 (DP1), Type-C1.B6 (DP2)
Teensy4.1_D-: J3.2, Type-C1.A7 (DN1), Type-C1.B7 (DN2)
X1: A1.D38 (A14), LINE1.6
X2: A1.D39 (A15), LINE1.5
X3: A1.D40 (A16), LINE1.4

Notes on the sheet:
Low V
High V
ボールセンサーの信号入力（RX,TXの変換措置はここで）
スイッチ類
カメラ用コネクタ（TX,RX逆転処置はここで、）
monitor
ラインセンサーコネクタ
Ball Catch(まだ抵抗値決めれてない)
Teensy4.1
レベル変換回路
ジャイロ（BNO055）
キッカー基板通信用
電源コネクタ
Teensy TYPE-C
ブザー
モタドラ基板通信用コネクタ

Board: 2 copper layers, 100.0 x 119.0 mm, 42 parts (8 on the bottom side), 43 nets.

File 2025中/MAIN/MAIN V1.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
A1,TEENSY4.1,1,TEENSY4.1,
BZ1,Buzzer UDX01CLFPH,1,Buzzer,
"C1, C26",0603,2,0.1μF,
C10,CP_Radial_D6.3mm_P2.50mm,1,100uF,
C11,0603,1,10uF,
C12,0603,1,0.1uF,
"CAMERA1, CAMERA2",GROVE-HW4-2.0,2,Conn_01x04_Pin,
"CATCHSENSOR1, LED1",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,2,Conn_01x02_Pin,
GYRO1,BNO055,1,Conn_01x08_Pin,
J1,PinSocket_2x04_P2.54mm_Vertical,1,Conn_02x04_Odd_Even,
"J2, KICK1",JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,2,Conn_01x03_Pin,
J3,PinSocket_1x02_P2.54mm_Vertical,1,Conn_01x02_Pin,
J6,FFC conector 0.5mm Pich,1,Conn_01x08_Pin,
LINE1,JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical,1,Conn_01x06_Pin,
MONITOR1,SSD1306 (akizuki),1,Conn_01x04_Pin,
"Q1, Q2",SOT-23,2,BSS138,
R1,0603,1,100,
"R10, R11, R3, R4",0603,4,10k,
"R12, R13, R14, R15, R5, R6, R7",0603,7,1kΩ,
"R16, R17",0603,2,5.1kΩ,
R2,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,R,
"TACT1, TACT2, TACT3",Big tact switch MAIN,3,SW_MEC_5G,
TACT4,SW_PUSH_6mm,1,SW_MEC_5G,
TOGGLESWITCH1,PinSocket_1x03_P2.54mm_Vertical,1,Conn_01x03_Pin,
TYPE-C1,NELTRON_5077CR-16SMC2-BK-TR,1,5077CR-16SMC2-BK-TR,

## KiCad design 2025中/MOTOR Driver/Motor Driver V1.1/Motor Driver V1.1.kicad_pcb

Parts:
C1, C2, C3, C4: 150uF; 293D157X9016D2TE3
C5, C6, C8, C9, C11, C12, C15: 0.1uF; C_0603_1608Metric
C7, C10, C16: 22nF; C_0603_1608Metric
C13: 22nF; C_0402_1005Metric
C14: 0.1uF; C_0402_1005Metric
D1: LED; LED_0603_1608Metric
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x08_Pin; FFC conector 0.5mm Pich
J2: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
Motor1, Motor2, Motor3, Motor4: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
R1, R3, R4, R5, R6, R7, R9, R10, R11, R13, R14, R15: 10k; R_0402_1005Metric
R2, R8, R12, R16: 2.49k; R_0402_1005Metric
R17: 150; R_0603_1608Metric
U1, U2, U3, U4: DRV8874PWPR; DRV8874 IC

Connections:
+3.3V: J2.2, R1.1, R3.1, R4.1, R5.1, R6.1, R7.1, R9.1, R10.1, R11.1, R13.1, R14.1, R15.1, U1.7 (IMODE), U1.16 (PMODE), U2.7 (IMODE), U2.16 (PMODE), U3.7 (IMODE), U3.16 (PMODE), U4.7 (IMODE), U4.16 (PMODE)
D1 OUT1: Motor1.1, U1.8 (OUT1)
D1 OUT2: Motor1.2, U1.10 (OUT2)
D1 PWM IN1: J1.6, U1.1 (EN/IN1)
D1 PWM IN2: J1.5, U1.2 (PH/IN2)
D2 OUT1: Motor4.1, U4.8 (OUT1)
D2 OUT2: Motor4.2, U4.10 (OUT2)
D2 PWM IN1: J1.8, U4.1 (EN/IN1)
D2 PWM IN2: J1.7, U4.2 (PH/IN2)
D3 OUT1: Motor3.1, U3.8 (OUT1)
D3 OUT2: Motor3.2, U3.10 (OUT2)
D3 PWM IN1: J1.2, U3.1 (EN/IN1)
D3 PWM IN2: J1.1, U3.2 (PH/IN2)
D4 OUT1: Motor2.1, U2.8 (OUT1)
D4 OUT2: Motor2.2, U2.10 (OUT2)
D4 PWM IN1: J1.4, U2.1 (EN/IN1)
D4 PWM IN2: J1.3, U2.2 (PH/IN2)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C9.2, C12.2, C15.2, D1.1 (K), J2.3, R2.2, R8.2, R12.2, R16.2, U1.9 (PGND), U1.15 (GND), U1.17 (PAD), U2.9 (PGND), U2.15 (GND), U2.17 (PAD), U3.9 (PGND), U3.15 (GND), U3.17 (PAD), U4.9 (PGND), U4.15 (GND), U4.17 (PAD)
unnamed: D1.2 (A), R17.2
unnamed: C13.1, U1.13 (CPH)
unnamed: C13.2, U1.14 (CPL)
unnamed: R2.1, U1.6 (IPROPI)
unnamed: R3.2, U1.4 (NFAULT)
unnamed: R1.2, U1.3 (NSLEEP)
unnamed: C14.2, U1.12 (VCP)
unnamed: R4.2, U1.5 (VREF)
unnamed: C10.1, U2.13 (CPH)
unnamed: C10.2, U2.14 (CPL)
unnamed: R16.1, U2.6 (IPROPI)
unnamed: R15.2, U2.4 (NFAULT)
unnamed: R13.2, U2.3 (NSLEEP)
unnamed: C11.2, U2.12 (VCP)
unnamed: R14.2, U2.5 (VREF)
unnamed: C7.1, U3.13 (CPH)
unnamed: C7.2, U3.14 (CPL)
unnamed: R12.1, U3.6 (IPROPI)
unnamed: R11.2, U3.4 (NFAULT)
unnamed: R9.2, U3.3 (NSLEEP)
unnamed: C8.2, U3.12 (VCP)
unnamed: R10.2, U3.5 (VREF)
unnamed: C16.1, U4.13 (CPH)
unnamed: C16.2, U4.14 (CPL)
unnamed: R8.1, U4.6 (IPROPI)
unnamed: R7.2, U4.4 (NFAULT)
unnamed: R5.2, U4.3 (NSLEEP)
unnamed: C5.2, U4.12 (VCP)
unnamed: R6.2, U4.5 (VREF)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, C9.1, C11.1, C12.1, C14.1, C15.1, J2.1, R17.1, U1.11 (VM), U2.11 (VM), U3.11 (VM), U4.11 (VM)

Notes on the sheet:
これはD4のこと
[悲報]Motor2とMotor4の配置をミスったためおかしなことになっていますが気にしないでください
これはD2のこと
コネクタ類
モーター出力コネクタ
モーター用コンデンサー
通電確認用LED
モタドラIC
