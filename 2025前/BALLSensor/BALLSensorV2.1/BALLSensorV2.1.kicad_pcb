# Repository kataoka95/KiCad-Print-Circuit-Board-date-buck-up

## KiCad design 2025前/BALLSensor/BALLSensorV2.1/BALLSensorV2.1.kicad_pcb

Parts:
A1, A2, A3, A4, A5, A6, A7, A8, A9, A10, A11, A12, A13, A14, A15, A16: TSSP4038; PARTREV 2.3
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Conn_01x09_Socket; PinHeader_1x09_P2.54mm_Vertical

Connections:
1-1: A8.1 (OUT), J1.1
1-2: A7.1 (OUT), J1.2
1-3: A6.1 (OUT), J1.3
1-4: A5.1 (OUT), J1.4
1-5: A4.1 (OUT), J1.5
1-6: A3.1 (OUT), J1.6
1-7: A2.1 (OUT), J1.7
1-8: A1.1 (OUT), J1.8
2-1: A16.1 (OUT), J2.1
2-2: A15.1 (OUT), J2.2
2-3: A14.1 (OUT), J2.3
2-4: A13.1 (OUT), J2.4
2-5: A12.1 (OUT), J2.5
2-6: A11.1 (OUT), J2.6
2-7: A10.1 (OUT), J2.7
2-8: A9.1 (OUT), J2.8
+5V: A1.3 (VS), A2.3 (VS), A3.3 (VS), A4.3 (VS), A5.3 (VS), A6.3 (VS), A7.3 (VS), A8.3 (VS), A9.3 (VS), A10.3 (VS), A11.3 (VS), A12.3 (VS), A13.3 (VS), A14.3 (VS), A15.3 (VS), A16.3 (VS), J1.9
GND: A1.2 (GND), A2.2 (GND), A3.2 (GND), A4.2 (GND), A5.2 (GND), A6.2 (GND), A7.2 (GND), A8.2 (GND), A9.2 (GND), A10.2 (GND), A11.2 (GND), A12.2 (GND), A13.2 (GND), A14.2 (GND), A15.2 (GND), A16.2 (GND), J2.9

Notes on the sheet:
ボールセンサーコネクタ
TSSP4038（ボールセンサー）基板

Board: 2 copper layers, 100.0 x 100.0 mm, 22 parts (0 on the bottom side), 18 nets.

## KiCad design 2025前/Ballcatch sensor/Ballcatch sensor.kicad_pcb

Parts:
A1, A2: TSSP4038; Vishay_MINICAST-3Pin; PARTREV 2.3
J1, J2: Conn_01x03_Pin; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical

Connections:
+5V: A1.3 (VS), A2.3 (VS), J1.1, J2.1
Ballsensor 1: A1.1 (OUT), J1.3
Ballsensor 2: A2.1 (OUT), J2.3
GND: A1.2 (GND), A2.2 (GND), J1.2, J2.2

Board: 2 copper layers, 29.0 x 42.0 mm, 4 parts (0 on the bottom side), 4 nets.

## KiCad design 2025前/ELECT/ELECT V1.1/ELECT V1.1.kicad_pcb

Parts:
Battry1, Battry2: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
DCDC_1, DCDC_2: Conn_01x03_Pin; PinSocket_1x03_P2.54mm_Vertical
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Line_1: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
MDR_1: Conn_01x03_Pin; PinSocket_1x03_P2.54mm_Vertical
Main_1: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
SW1: SW_DPST_x2; PinSocket_1x02_P2.54mm_Vertical

Connections:
+5V: DCDC_2.1, Line_1.1, MDR_1.2
GND: Battry2.2, DCDC_1.3, DCDC_2.3, Line_1.2, MDR_1.3, Main_1.2
unnamed: Battry1.1, SW1.1 (A)
unnamed: Battry1.2, Battry2.1
VCC: DCDC_1.1, MDR_1.1, Main_1.1, SW1.2 (B)

Board: 2 copper layers, 80.0 x 45.0 mm, 16 parts (0 on the bottom side), 5 nets.

File 2025前/ELECT/ELECT V2.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"BATTRY1, BATTRY2",AMASS_XT30U-M_1x02_P5.0mm_Vertical,2,Conn_01x02_Pin,
C1,CP_Elec_10x10.5,1,C_Polarized,
"DCDC_1, DCDC_2, MDR_1",PinSocket_1x03_P2.54mm_Vertical,3,Conn_01x03_Pin,
J1,PinHeader_1x02_P2.54mm_Vertical,1,Conn_01x02_Pin,
LINE_1,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,Conn_01x02_Pin,
MAIN1,JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal,1,Conn_01x03_Pin,
SW1,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,SW_DPST_x2,

## KiCad design 2025前/ELECT/ELECT V2.1/ELECT V2.1.kicad_pcb

Parts:
Battry1, Battry2: Conn_01x02_Pin; AMASS_XT30U-M_1x02_P5.0mm_Vertical
C1: C_Polarized; CP_Elec_10x10.5
DCDC_1, DCDC_2: Conn_01x03_Pin; PinSocket_1x03_P2.54mm_Vertical
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
Line_1: Conn_01x02_Pin; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
MAIN1: Conn_01x03_Pin; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
MDR2: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
MDR_1: Conn_01x03_Pin; PinSocket_1x03_P2.54mm_Vertical
SW1: SW_DPST_x2; AMASS_XT30U-M_1x02_P5.0mm_Vertical

Connections:
+5V: DCDC_2.1, Line_1.1, MAIN1.2, MDR_1.2
Ba→Ba: Battry1.1, Battry2.2
Ba→Sw: Battry1.2, SW1.1 (A)
GND: Battry2.1, C1.2, DCDC_1.3, DCDC_2.3, J1.2, Line_1.2, MAIN1.3, MDR_1.3
VCC: C1.1, DCDC_1.1, J1.1, MAIN1.1, MDR_1.1, SW1.2 (B)

Notes on the sheet:
5V生成DCコンバーター
簡易電圧計用
外部電源供給
SW(波動スイッチ)
Battry(9.6V)
モタドラ電源供給用
コンデンサー

Board: 2 copper layers, 80.0 x 45.0 mm, 18 parts (2 on the bottom side), 5 nets.

## KiCad design 2025前/LINEsensor/LINESensorV1.1/enjoy!!!.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: LED; LED_D5.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
R1: 150; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+5V: J1.1, R1.2
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), J1.2
unnamed: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), R1.1

Board: 2 copper layers, 246.0 x 246.0 mm, 30 parts (0 on the bottom side), 3 nets.

## KiCad design 2025前/LINEsensor/LINESensorV2.1/LINESensorV2.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: LED; LED_D5.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IC1, IC2, IC3: TC4051BP_THT; Manufacturer_Part_Number TC4051BP(N,F)
J1: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: Conn_01x06_Pin; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
R1: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
T1, T2, T3, T4, T5, T6, T7, T8, T9, T10, T11, T12, T13, T14, T15, T16, T17, T18, T19, T20, T21, T22, T23, T24: FT; LED_D5.0mm

Connections:
+5V: J1.1, R1.2, T1.2 (A), T2.2 (A), T3.2 (A), T4.2 (A), T5.2 (A), T6.2 (A), T7.2 (A), T8.2 (A), T9.2 (A), T10.2 (A), T11.2 (A), T12.2 (A), T13.2 (A), T14.2 (A), T15.2 (A), T16.2 (A), T17.2 (A), T18.2 (A), T19.2 (A), T20.2 (A), T21.2 (A), T22.2 (A), T23.2 (A), T24.2 (A)
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), J1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2
unnamed: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), R1.1
unnamed: R2.1, T1.1 (K)
unnamed: R3.1, T2.1 (K)
unnamed: R4.1, T3.1 (K)
unnamed: R5.1, T4.1 (K)
unnamed: R6.1, T5.1 (K)
unnamed: R7.1, T6.1 (K)
unnamed: R8.1, T7.1 (K)
unnamed: R9.1, T8.1 (K)
unnamed: R10.1, T9.1 (K)
unnamed: R11.1, T10.1 (K)
unnamed: R12.1, T11.1 (K)
unnamed: R13.1, T12.1 (K)
unnamed: R14.1, T13.1 (K)
unnamed: R15.1, T14.1 (K)
unnamed: R16.1, T15.1 (K)
unnamed: R17.1, T16.1 (K)
unnamed: R18.1, T17.1 (K)
unnamed: R19.1, T18.1 (K)
unnamed: R20.1, T19.1 (K)
unnamed: R21.1, T20.1 (K)
unnamed: R22.1, T21.1 (K)
unnamed: R23.1, T22.1 (K)
unnamed: R24.1, T23.1 (K)
unnamed: R25.1, T24.1 (K)

Board: 2 copper layers, 82 parts (0 on the bottom side), 27 nets, no tracks yet.
