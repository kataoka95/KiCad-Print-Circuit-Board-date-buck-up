# Repository kataoka95/KiCad-Print-Circuit-Board-date-buck-up (continued)

## KiCad design 2025前/MOTORDRIVE/MOTORDRIVEV2.1/MOTORDRIVEV2.1.kicad_pcb

Parts:
C1, C2, C3, C4: 150μF; CP_Radial_D8.0mm_P3.50mm
D1, D2, D3, D4: DRV8835
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x08_Pin; CON_522710879_MOL
MOTOR_1, MOTOR_2, MOTOR_3, MOTOR_4: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
電源111: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical

Connections:
+5V: D1.12 (+5V), D2.12 (+5V), D3.12 (+5V), D4.12 (+5V), 電源111.2
D1 IN1: D1.8 (BIN1), D1.10 (AIN1), J1.1
D1 IN2: D1.7 (BIN2), D1.9 (AIN2), J1.2
D1 OUT1: D1.2 (AOUT1), D1.4 (BOUT1), MOTOR_1.2
D1 OUT2: D1.3 (AOUT2), D1.5 (BOUT2), MOTOR_1.1
D2 IN1: D2.8 (BIN1), D2.10 (AIN1), J1.3
D2 IN2: D2.7 (BIN2), D2.9 (AIN2), J1.4
D2 OUT1: D2.2 (AOUT1), D2.4 (BOUT1), MOTOR_2.2
D2 OUT2: D2.3 (AOUT2), D2.5 (BOUT2), MOTOR_2.1
D3 IN1: D3.8 (BIN1), D3.10 (AIN1), J1.5
D3 IN2: D3.7 (BIN2), D3.9 (AIN2), J1.6
D3 OUT1: D3.2 (AOUT1), D3.4 (BOUT1), MOTOR_3.2
D3 OUT2: D3.3 (AOUT2), D3.5 (BOUT2), MOTOR_3.1
D4 IN1: D4.8 (BIN1), D4.10 (AIN1), J1.7
D4 IN2: D4.7 (BIN2), D4.9 (AIN2), J1.8
D4 OUT1: D4.2 (AOUT1), D4.4 (BOUT1), MOTOR_4.2
D4 OUT2: D4.3 (AOUT2), D4.5 (BOUT2), MOTOR_4.1
GND: C1.2, C2.2, C3.2, C4.2, D1.6 (GND), D1.11 (MODE), D2.6 (GND), D2.11 (MODE), D3.6 (GND), D3.11 (MODE), D4.6 (GND), D4.11 (MODE), 電源111.3
VCC: C1.1, C2.1, C3.1, C4.1, D1.1 (VCC), D2.1 (VCC), D3.1 (VCC), D4.1 (VCC), 電源111.1

Notes on the sheet:
DRV8835（モタドラ）回路
動作安定化用コンデンサー
モタドラ用FFCコネクタ

Board: 2 copper layers, 80.0 x 45.0 mm, 18 parts (1 on the bottom side), 19 nets.

File 2025前/MOTORDRIVE/MOTORDRIVEV2.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4",CP_Radial_D8.0mm_P3.50mm,4,150μF,
"D1, D2, D3, D4",DRV8835,4,~,
J1,CON_522710879_MOL,1,Conn_01x08_Pin,
"MOTOR_1, MOTOR_2, MOTOR_3, MOTOR_4",JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,4,Conn_01x02_Socket,
電源,PinHeader_1x03_P2.54mm_Vertical,1,Conn_01x03_Pin,
