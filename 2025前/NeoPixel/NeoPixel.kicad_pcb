# Repository kataoka95/KiCad-Print-Circuit-Board-date-buck-up

## KiCad design 2025前/NeoPixel/NeoPixel.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: 0.1μF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1: Conn_01x03_Socket; PinHeader_1x03_P2.54mm_Vertical
R1: 330; R_0805_2012Metric

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), J1.1
/L1: D8.2 (DOUT), D9.4 (DIN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), J1.3
unnamed: D1.4 (DIN), R1.1
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D12.2 (DOUT), D13.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)
unnamed: J1.2, R1.2

Board: 2 copper layers, 34 parts (0 on the bottom side), 19 nets, no tracks yet.

## KiCad design 2025前/最初に作ったやつ/LEDSwith/test.kicad_pcb

Board: 2 copper layers, 45.0 x 23.0 mm, 4 parts (0 on the bottom side), 4 nets.

Parts:
D1: LED; LED_D5.0mm
J1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
R1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_DPST_x2; PinHeader_1x03_P2.54mm_Vertical

Connections:
GND: J1.2, SW1.1 (A)
unnamed: D1.2 (A), R1.2
unnamed: D1.1 (K), SW1.3
VCC: J1.1, R1.1

## KiCad design 2025後/BallSensor/BallSensorV1.1/BallSensor.kicad_pcb

Parts:
A1, A2, A3, A4, A5, A6, A7, A8, A9, A10, A11, A12, A13, A14, A15, A16: TSSP4038; PARTREV 2.3
C1: 1uF; C_0603_1608Metric
C2, C3, C27, C28, C29, C30, C31, C32, C33, C34: 0.1uF; C_0402_1005Metric
C4, C5, C6, C25: 0.1uF; C_0603_1608Metric
C8: 4.7uF; C_0603_1608Metric
C26: 0.1μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C35: 100uF; C_1206_3216Metric
C36: 47uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D17: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D18: D_Schottky; D_SMA
D21: LED; LED_0603_1608Metric
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J2: Conn_01x05_Pin; PinSocket_1x05_P2.54mm_Vertical
Q1: BSS138; SOT-23
R3, R10: 10k; R_0402_1005Metric
R4: 1k; R_0402_1005Metric
R5, R6: 22Ω; R_0402_1005Metric
R7: 10kΩ; R_0603_1608Metric
R8, R9, R16, R17: 5.1kΩ; R_0402_1005Metric
R11: 150Ω; R_0402_1005Metric
R12, R13, R14, R15: 1kΩ; R_0402_1005Metric
SW2: SW_MEC_5G; Reset switch
TACT1, TACT2, TACT3: SW_MEC_5G; Big tact switch MAIN
TOGGLE1: Conn_01x03_Pin; PinSocket_1x03_P2.54mm_Vertical
Type-C1, Type-C2: 5077CR-16SMC2-BK-TR; NELTRON_5077CR-16SMC2-BK-TR; PARTREV B
U1: XIAO ESP32 S3; XIAO-ESP32S3-DIP
U2: ATmega32U4-A; TQFP-44_10x10mm_P0.8mm
U3, U4: ADM3202ARUZ-REEL7; RU_16_ADI
Y1: CSTCE16M0V53-R0; OSC_CSTCE16M0V53-R0; PARTREV 10/24/2022
monitor1: Conn_01x04_Pin; SSD1306 (akizuki)

Connections:
2C1+: C2.2, U3.1 (C1+)
2C1-: C2.1, U3.3 (C1-)
2C2+: C3.2, U3.4 (C2+)
2C2-: C3.1, U3.5 (C2-)
2V+: C27.2, U3.2 (V+)
2V-: C29.2, U3.6 (V-)
+3.3V: C26.1, C27.1, C28.1, Q1.1 (G), R10.1, R12.1, R13.1, R14.1, R15.1, U1.12 (VCC_3V3), U3.16 (VCC), monitor1.3
+5V: A1.3 (VS), A2.3 (VS), A3.3 (VS), A4.3 (VS), A5.3 (VS), A6.3 (VS), A7.3 (VS), A8.3 (VS), A9.3 (VS), A10.3 (VS), A11.3 (VS), A12.3 (VS), A13.3 (VS), A14.3 (VS), A15.3 (VS), A16.3 (VS), C4.2, C5.2, C6.2, C8.2, C25.1, C32.1, C34.1, C35.1, C36.1, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), D18.2 (A), J1.2, R3.1, R7.1, R11.1, U2.2 (UVCC), U2.7 (VBUS), U2.14 (VCC), U2.24 (AVCC), U2.34 (VCC), U2.42 (AREF), U2.44 (AVCC), U4.16 (VCC)
A1: R12.2, TACT1.1 (A), TACT1.2 (A), U1.2 (D1)
A2: R13.2, TACT2.1 (A), TACT2.2 (A), U1.3 (D2)
A3: R14.2, TACT3.1 (A), TACT3.2 (A), U1.4 (D3)
Ball1: A1.1 (OUT), U2.26 (PD6)
Ball2: A2.1 (OUT), U2.27 (PD7)
Ball3: A3.1 (OUT), U2.28 (PB4)
Ball4: A4.1 (OUT), U2.29 (PB5)
Ball5: A5.1 (OUT), U2.30 (PB6)
Ball6: A6.1 (OUT), U2.36 (PF7)
Ball7: A7.1 (OUT), U2.37 (PF6)
Ball8: A8.1 (OUT), U2.38 (PF5)
Ball9: A9.1 (OUT), U2.39 (PF4)
Ball10: A10.1 (OUT), U2.40 (PF1)
Ball11: A11.1 (OUT), U2.8 (PB0)
Ball12: A12.1 (OUT), J2.5, U2.9 (PB1)
Ball13: A13.1 (OUT), J2.4, U2.10 (PB2)
Ball14: A14.1 (OUT), J2.3, U2.11 (PB3)
Ball15: A15.1 (OUT), U2.19 (PD1)
Ball16: A16.1 (OUT), U2.22 (PD5)
C1+: C30.2, U4.1 (C1+)
C1-: C30.1, U4.3 (C1-)
C2+: C31.2, U4.4 (C2+)
C2-: C31.1, U4.5 (C2-)
D8: R15.2, TOGGLE1.2, U1.9 (D8)
D+_Ballusb1: R5.1, U2.4 (D+)
D+_Ballusb2: R5.2, Type-C1.A6 (DP1), Type-C1.B6 (DP2)
D+_Teensy usb: J1.7, Type-C2.A6 (DP1), Type-C2.B6 (DP2)
D-_Ballusb1: R6.1, U2.3 (D-)
D-_Ballusb2: R6.2, Type-C1.A7 (DN1), Type-C1.B7 (DN2)
D-_Teensy usb: J1.8, Type-C2.A7 (DN1), Type-C2.B7 (DN2)
GND: A1.2 (GND), A2.2 (GND), A3.2 (GND), A4.2 (GND), A5.2 (GND), A6.2 (GND), A7.2 (GND), A8.2 (GND), A9.2 (GND), A10.2 (GND), A11.2 (GND), A12.2 (GND), A13.2 (GND), A14.2 (GND), A15.2 (GND), A16.2 (GND), C1.2, C4.1, C5.1, C6.1, C8.1, C25.2, C26.2, C28.2, C29.1, C33.1, C34.2, C35.2, C36.2, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), D17.1 (K), D21.1 (K), J1.1, J2.1, R8.1, R9.2, R16.1, R17.2, SW2.1 (A), SW2.2 (A), TACT1.3 (B), TACT1.4 (B), TACT2.3 (B), TACT2.4 (B), TACT3.3 (B), TACT3.4 (B), TOGGLE1.3, Type-C1.A1_B12 (GND), Type-C1.B1_A12 (GND), Type-C1.S1 (SHIELD), Type-C1.S2 (SHIELD), Type-C1.S3 (SHIELD), Type-C1.S4 (SHIELD), Type-C2.A1_B12 (GND), Type-C2.B1_A12 (GND), Type-C2.S1 (SHIELD), Type-C2.S2 (SHIELD), Type-C2.S3 (SHIELD), Type-C2.S4 (SHIELD), U1.13 (GND), U2.5 (UGND), U2.15 (GND), U2.23 (GND), U2.35 (GND), U2.43 (GND), U3.15 (GND), U4.15 (GND), Y1.2, monitor1.4
NeoPixel A0: D13.4 (DIN), Q1.3 (D), R3.2
NeoPixel ESP A0: Q1.2 (S), R10.2, U1.1 (D0)
NeoPixel connect: D8.2 (DOUT), D9.4 (DIN)
unnamed: D1.4 (DIN), D16.2 (DOUT)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)
unnamed: D17.2 (A), R11.2
unnamed: D18.1 (K), U1.14 (VUSB)
unnamed: D21.2 (A), R4.2
unnamed: R8.2, Type-C1.A5 (CC1)
unnamed: R9.1, Type-C1.B5 (CC2)
unnamed: R16.2, Type-C2.A5 (CC1)
unnamed: R17.1, Type-C2.B5 (CC2)
unnamed: R4.1, U2.32 (PC7)
unnamed: C1.1, U2.6 (UCAP)
RX_Ball: U2.20 (PD2), U4.9 (R2OUT)
RX_Ball RS232C: J1.4, U4.8 (R2IN)
RX_ESP: U1.8 (D7), U3.9 (R2OUT)
RX_ESP RS232C: J1.6, U3.8 (R2IN)
SCL(monitor): U1.6 (D5), monitor1.2
SDA(monitor): U1.5 (D4), monitor1.1
SPI_RESET: J2.2, R7.2, SW2.3 (B), SW2.4 (B), U2.13 (~RESET)
TX_Ball: U2.21 (PD3), U4.10 (T2IN)
TX_Ball RC232C: J1.3, U4.7 (T2OUT)
TX_ESP: U1.7 (D6), U3.10 (T2IN)
TX_ESP RC232C: J1.5, U3.7 (T2OUT)
V+: C32.2, U4.2 (V+)
V-: C33.2, U4.6 (V-)
XTAL1: U2.17 (XTAL1), Y1.1
XTAL2: U2.16 (XTAL2), Y1.3

Notes on the sheet:
ネオピクの直前
マイコンの安定動作用
RS232Cレベル変換回路
Swich
NeoPixel
コネクター類
Teensy TYPE-C
ATmega32u4マイコン
XIAO ESP32 S3
ボールセンサー素子（TSSP4038）
BallSensor USB-C
monitor

Board: 2 copper layers, 103.5 x 120.0 mm, 90 parts (27 on the bottom side), 80 nets.

Other parts of the board:
M2.5, M2.5#2, M2.5#3: MountingHole_2.7mm_M2.5

File 2025後/BallSensor/BallSensorV1.1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"A1, A10, A11, A12, A13, A14, A15, A16, A2, A3, A4, A5, A6, A7, A8, A9",TSSP4038,16,TSSP4038,
C1,0603,1,1uF,
"C2, C27, C28, C29, C3, C30, C31, C32, C33, C34",0402,10,0.1uF,
"C25, C4, C5, C6",0603,4,0.1uF,
C26,0603,1,0.1μF,
C35,1206,1,100uF,
C36,0603,1,47uF,
C8,0603,1,4.7uF,
"D1, D10, D11, D12, D13, D14, D15, D16, D2, D3, D4, D5, D6, D7, D8, D9",LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,16,WS2812B,
"D17, D21",0603,2,LED,
D18,D_SMA,1,D_Schottky,
J1,PinHeader_2x04_P2.54mm_Vertical,1,Conn_02x04_Odd_Even,
J2,PinSocket_1x05_P2.54mm_Vertical,1,Conn_01x05_Pin,
MONITOR1,SSD1306 (akizuki),1,Conn_01x04_Pin,
Q1,SOT-23,1,BSS138,
"R10, R3",0402,2,10k,
R11,0402,1,150Ω,
"R12, R13, R14, R15",0402,4,1kΩ,
"R16, R17, R8, R9",0402,4,5.1kΩ,
R4,0402,1,1k,
"R5, R6",0402,2,22Ω,
R7,0603,1,10kΩ,
SW2,Reset switch,1,SW_MEC_5G,
"TACT1, TACT2, TACT3",Big tact switch MAIN,3,SW_MEC_5G,
TOGGLE1,PinSocket_1x03_P2.54mm_Vertical,1,Conn_01x03_Pin,
"TYPE-C1, TYPE-C2",NELTRON_5077CR-16SMC2-BK-TR,2,5077CR-16SMC2-BK-TR,
U1,XIAO-ESP32S3-DIP,1,XIAO ESP32 S3,
U2,TQFP-44_10x10mm_P0.8mm,1,ATmega32U4-A,
"U3, U4",RU_16_ADI,2,ADM3202ARUZ-REEL7,
Y1,OSC_CSTCE16M0V53-R0,1,CSTCE16M0V53-R0,
